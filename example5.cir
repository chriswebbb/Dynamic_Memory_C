V 0 9999 1
R0 0 1 1
R1 100 101 1
R2 200 201 1
R3 300 301 1
R4 400 401 1
R5 500 501 1
R6 600 601 1
R7 700 701 1
R8 800 801 1
R9 900 901 1
R10 1000 1001 1
R11 1100 1101 1
R12 1200 1201 1
R13 1300 1301 1
R14 1400 1401 1
R15 1500 1501 1
R16 1600 1601 1
R17 1700 1701 1
R18 1800 1801 1
R19 1900 1901 1
R20 2000 2001 1
R21 2100 2101 1
R22 2200 2201 1
R23 2300 2301 1
R24 2400 2401 1
R25 2500 2501 1
R26 2600 2601 1
R27 2700 2701 1
R28 2800 2801 1
R29 2900 2901 1
R30 3000 3001 1
R31 3100 3101 1
R32 3200 3201 1
R33 3300 3301 1
R34 3400 3401 1
R35 3500 3501 1
R36 3600 3601 1
R37 3700 3701 1
R38 3800 3801 1
R39 3900 3901 1
R40 4000 4001 1
R41 4100 4101 1
R42 4200 4201 1
R43 4300 4301 1
R44 4400 4401 1
R45 4500 4501 1
R46 4600 4601 1
R47 4700 4701 1
R48 4800 4801 1
R49 4900 4901 1
R50 5000 5001 1
R51 5100 5101 1
R52 5200 5201 1
R53 5300 5301 1
R54 5400 5401 1
R55 5500 5501 1
R56 5600 5601 1
R57 5700 5701 1
R58 5800 5801 1
R59 5900 5901 1
R60 6000 6001 1
R61 6100 6101 1
R62 6200 6201 1
R63 6300 6301 1
R64 6400 6401 1
R65 6500 6501 1
R66 6600 6601 1
R67 6700 6701 1
R68 6800 6801 1
R69 6900 6901 1
R70 7000 7001 1
R71 7100 7101 1
R72 7200 7201 1
R73 7300 7301 1
R74 7400 7401 1
R75 7500 7501 1
R76 7600 7601 1
R77 7700 7701 1
R78 7800 7801 1
R79 7900 7901 1
R80 8000 8001 1
R81 8100 8101 1
R82 8200 8201 1
R83 8300 8301 1
R84 8400 8401 1
R85 8500 8501 1
R86 8600 8601 1
R87 8700 8701 1
R88 8800 8801 1
R89 8900 8901 1
R90 9000 9001 1
R91 9100 9101 1
R92 9200 9201 1
R93 9300 9301 1
R94 9400 9401 1
R95 9500 9501 1
R96 9600 9601 1
R97 9700 9701 1
R98 9800 9801 1
R99 9900 9901 1
R100 1 2 1
R101 101 102 1
R102 201 202 1
R103 301 302 1
R104 401 402 1
R105 501 502 1
R106 601 602 1
R107 701 702 1
R108 801 802 1
R109 901 902 1
R110 1001 1002 1
R111 1101 1102 1
R112 1201 1202 1
R113 1301 1302 1
R114 1401 1402 1
R115 1501 1502 1
R116 1601 1602 1
R117 1701 1702 1
R118 1801 1802 1
R119 1901 1902 1
R120 2001 2002 1
R121 2101 2102 1
R122 2201 2202 1
R123 2301 2302 1
R124 2401 2402 1
R125 2501 2502 1
R126 2601 2602 1
R127 2701 2702 1
R128 2801 2802 1
R129 2901 2902 1
R130 3001 3002 1
R131 3101 3102 1
R132 3201 3202 1
R133 3301 3302 1
R134 3401 3402 1
R135 3501 3502 1
R136 3601 3602 1
R137 3701 3702 1
R138 3801 3802 1
R139 3901 3902 1
R140 4001 4002 1
R141 4101 4102 1
R142 4201 4202 1
R143 4301 4302 1
R144 4401 4402 1
R145 4501 4502 1
R146 4601 4602 1
R147 4701 4702 1
R148 4801 4802 1
R149 4901 4902 1
R150 5001 5002 1
R151 5101 5102 1
R152 5201 5202 1
R153 5301 5302 1
R154 5401 5402 1
R155 5501 5502 1
R156 5601 5602 1
R157 5701 5702 1
R158 5801 5802 1
R159 5901 5902 1
R160 6001 6002 1
R161 6101 6102 1
R162 6201 6202 1
R163 6301 6302 1
R164 6401 6402 1
R165 6501 6502 1
R166 6601 6602 1
R167 6701 6702 1
R168 6801 6802 1
R169 6901 6902 1
R170 7001 7002 1
R171 7101 7102 1
R172 7201 7202 1
R173 7301 7302 1
R174 7401 7402 1
R175 7501 7502 1
R176 7601 7602 1
R177 7701 7702 1
R178 7801 7802 1
R179 7901 7902 1
R180 8001 8002 1
R181 8101 8102 1
R182 8201 8202 1
R183 8301 8302 1
R184 8401 8402 1
R185 8501 8502 1
R186 8601 8602 1
R187 8701 8702 1
R188 8801 8802 1
R189 8901 8902 1
R190 9001 9002 1
R191 9101 9102 1
R192 9201 9202 1
R193 9301 9302 1
R194 9401 9402 1
R195 9501 9502 1
R196 9601 9602 1
R197 9701 9702 1
R198 9801 9802 1
R199 9901 9902 1
R200 2 3 1
R201 102 103 1
R202 202 203 1
R203 302 303 1
R204 402 403 1
R205 502 503 1
R206 602 603 1
R207 702 703 1
R208 802 803 1
R209 902 903 1
R210 1002 1003 1
R211 1102 1103 1
R212 1202 1203 1
R213 1302 1303 1
R214 1402 1403 1
R215 1502 1503 1
R216 1602 1603 1
R217 1702 1703 1
R218 1802 1803 1
R219 1902 1903 1
R220 2002 2003 1
R221 2102 2103 1
R222 2202 2203 1
R223 2302 2303 1
R224 2402 2403 1
R225 2502 2503 1
R226 2602 2603 1
R227 2702 2703 1
R228 2802 2803 1
R229 2902 2903 1
R230 3002 3003 1
R231 3102 3103 1
R232 3202 3203 1
R233 3302 3303 1
R234 3402 3403 1
R235 3502 3503 1
R236 3602 3603 1
R237 3702 3703 1
R238 3802 3803 1
R239 3902 3903 1
R240 4002 4003 1
R241 4102 4103 1
R242 4202 4203 1
R243 4302 4303 1
R244 4402 4403 1
R245 4502 4503 1
R246 4602 4603 1
R247 4702 4703 1
R248 4802 4803 1
R249 4902 4903 1
R250 5002 5003 1
R251 5102 5103 1
R252 5202 5203 1
R253 5302 5303 1
R254 5402 5403 1
R255 5502 5503 1
R256 5602 5603 1
R257 5702 5703 1
R258 5802 5803 1
R259 5902 5903 1
R260 6002 6003 1
R261 6102 6103 1
R262 6202 6203 1
R263 6302 6303 1
R264 6402 6403 1
R265 6502 6503 1
R266 6602 6603 1
R267 6702 6703 1
R268 6802 6803 1
R269 6902 6903 1
R270 7002 7003 1
R271 7102 7103 1
R272 7202 7203 1
R273 7302 7303 1
R274 7402 7403 1
R275 7502 7503 1
R276 7602 7603 1
R277 7702 7703 1
R278 7802 7803 1
R279 7902 7903 1
R280 8002 8003 1
R281 8102 8103 1
R282 8202 8203 1
R283 8302 8303 1
R284 8402 8403 1
R285 8502 8503 1
R286 8602 8603 1
R287 8702 8703 1
R288 8802 8803 1
R289 8902 8903 1
R290 9002 9003 1
R291 9102 9103 1
R292 9202 9203 1
R293 9302 9303 1
R294 9402 9403 1
R295 9502 9503 1
R296 9602 9603 1
R297 9702 9703 1
R298 9802 9803 1
R299 9902 9903 1
R300 3 4 1
R301 103 104 1
R302 203 204 1
R303 303 304 1
R304 403 404 1
R305 503 504 1
R306 603 604 1
R307 703 704 1
R308 803 804 1
R309 903 904 1
R310 1003 1004 1
R311 1103 1104 1
R312 1203 1204 1
R313 1303 1304 1
R314 1403 1404 1
R315 1503 1504 1
R316 1603 1604 1
R317 1703 1704 1
R318 1803 1804 1
R319 1903 1904 1
R320 2003 2004 1
R321 2103 2104 1
R322 2203 2204 1
R323 2303 2304 1
R324 2403 2404 1
R325 2503 2504 1
R326 2603 2604 1
R327 2703 2704 1
R328 2803 2804 1
R329 2903 2904 1
R330 3003 3004 1
R331 3103 3104 1
R332 3203 3204 1
R333 3303 3304 1
R334 3403 3404 1
R335 3503 3504 1
R336 3603 3604 1
R337 3703 3704 1
R338 3803 3804 1
R339 3903 3904 1
R340 4003 4004 1
R341 4103 4104 1
R342 4203 4204 1
R343 4303 4304 1
R344 4403 4404 1
R345 4503 4504 1
R346 4603 4604 1
R347 4703 4704 1
R348 4803 4804 1
R349 4903 4904 1
R350 5003 5004 1
R351 5103 5104 1
R352 5203 5204 1
R353 5303 5304 1
R354 5403 5404 1
R355 5503 5504 1
R356 5603 5604 1
R357 5703 5704 1
R358 5803 5804 1
R359 5903 5904 1
R360 6003 6004 1
R361 6103 6104 1
R362 6203 6204 1
R363 6303 6304 1
R364 6403 6404 1
R365 6503 6504 1
R366 6603 6604 1
R367 6703 6704 1
R368 6803 6804 1
R369 6903 6904 1
R370 7003 7004 1
R371 7103 7104 1
R372 7203 7204 1
R373 7303 7304 1
R374 7403 7404 1
R375 7503 7504 1
R376 7603 7604 1
R377 7703 7704 1
R378 7803 7804 1
R379 7903 7904 1
R380 8003 8004 1
R381 8103 8104 1
R382 8203 8204 1
R383 8303 8304 1
R384 8403 8404 1
R385 8503 8504 1
R386 8603 8604 1
R387 8703 8704 1
R388 8803 8804 1
R389 8903 8904 1
R390 9003 9004 1
R391 9103 9104 1
R392 9203 9204 1
R393 9303 9304 1
R394 9403 9404 1
R395 9503 9504 1
R396 9603 9604 1
R397 9703 9704 1
R398 9803 9804 1
R399 9903 9904 1
R400 4 5 1
R401 104 105 1
R402 204 205 1
R403 304 305 1
R404 404 405 1
R405 504 505 1
R406 604 605 1
R407 704 705 1
R408 804 805 1
R409 904 905 1
R410 1004 1005 1
R411 1104 1105 1
R412 1204 1205 1
R413 1304 1305 1
R414 1404 1405 1
R415 1504 1505 1
R416 1604 1605 1
R417 1704 1705 1
R418 1804 1805 1
R419 1904 1905 1
R420 2004 2005 1
R421 2104 2105 1
R422 2204 2205 1
R423 2304 2305 1
R424 2404 2405 1
R425 2504 2505 1
R426 2604 2605 1
R427 2704 2705 1
R428 2804 2805 1
R429 2904 2905 1
R430 3004 3005 1
R431 3104 3105 1
R432 3204 3205 1
R433 3304 3305 1
R434 3404 3405 1
R435 3504 3505 1
R436 3604 3605 1
R437 3704 3705 1
R438 3804 3805 1
R439 3904 3905 1
R440 4004 4005 1
R441 4104 4105 1
R442 4204 4205 1
R443 4304 4305 1
R444 4404 4405 1
R445 4504 4505 1
R446 4604 4605 1
R447 4704 4705 1
R448 4804 4805 1
R449 4904 4905 1
R450 5004 5005 1
R451 5104 5105 1
R452 5204 5205 1
R453 5304 5305 1
R454 5404 5405 1
R455 5504 5505 1
R456 5604 5605 1
R457 5704 5705 1
R458 5804 5805 1
R459 5904 5905 1
R460 6004 6005 1
R461 6104 6105 1
R462 6204 6205 1
R463 6304 6305 1
R464 6404 6405 1
R465 6504 6505 1
R466 6604 6605 1
R467 6704 6705 1
R468 6804 6805 1
R469 6904 6905 1
R470 7004 7005 1
R471 7104 7105 1
R472 7204 7205 1
R473 7304 7305 1
R474 7404 7405 1
R475 7504 7505 1
R476 7604 7605 1
R477 7704 7705 1
R478 7804 7805 1
R479 7904 7905 1
R480 8004 8005 1
R481 8104 8105 1
R482 8204 8205 1
R483 8304 8305 1
R484 8404 8405 1
R485 8504 8505 1
R486 8604 8605 1
R487 8704 8705 1
R488 8804 8805 1
R489 8904 8905 1
R490 9004 9005 1
R491 9104 9105 1
R492 9204 9205 1
R493 9304 9305 1
R494 9404 9405 1
R495 9504 9505 1
R496 9604 9605 1
R497 9704 9705 1
R498 9804 9805 1
R499 9904 9905 1
R500 5 6 1
R501 105 106 1
R502 205 206 1
R503 305 306 1
R504 405 406 1
R505 505 506 1
R506 605 606 1
R507 705 706 1
R508 805 806 1
R509 905 906 1
R510 1005 1006 1
R511 1105 1106 1
R512 1205 1206 1
R513 1305 1306 1
R514 1405 1406 1
R515 1505 1506 1
R516 1605 1606 1
R517 1705 1706 1
R518 1805 1806 1
R519 1905 1906 1
R520 2005 2006 1
R521 2105 2106 1
R522 2205 2206 1
R523 2305 2306 1
R524 2405 2406 1
R525 2505 2506 1
R526 2605 2606 1
R527 2705 2706 1
R528 2805 2806 1
R529 2905 2906 1
R530 3005 3006 1
R531 3105 3106 1
R532 3205 3206 1
R533 3305 3306 1
R534 3405 3406 1
R535 3505 3506 1
R536 3605 3606 1
R537 3705 3706 1
R538 3805 3806 1
R539 3905 3906 1
R540 4005 4006 1
R541 4105 4106 1
R542 4205 4206 1
R543 4305 4306 1
R544 4405 4406 1
R545 4505 4506 1
R546 4605 4606 1
R547 4705 4706 1
R548 4805 4806 1
R549 4905 4906 1
R550 5005 5006 1
R551 5105 5106 1
R552 5205 5206 1
R553 5305 5306 1
R554 5405 5406 1
R555 5505 5506 1
R556 5605 5606 1
R557 5705 5706 1
R558 5805 5806 1
R559 5905 5906 1
R560 6005 6006 1
R561 6105 6106 1
R562 6205 6206 1
R563 6305 6306 1
R564 6405 6406 1
R565 6505 6506 1
R566 6605 6606 1
R567 6705 6706 1
R568 6805 6806 1
R569 6905 6906 1
R570 7005 7006 1
R571 7105 7106 1
R572 7205 7206 1
R573 7305 7306 1
R574 7405 7406 1
R575 7505 7506 1
R576 7605 7606 1
R577 7705 7706 1
R578 7805 7806 1
R579 7905 7906 1
R580 8005 8006 1
R581 8105 8106 1
R582 8205 8206 1
R583 8305 8306 1
R584 8405 8406 1
R585 8505 8506 1
R586 8605 8606 1
R587 8705 8706 1
R588 8805 8806 1
R589 8905 8906 1
R590 9005 9006 1
R591 9105 9106 1
R592 9205 9206 1
R593 9305 9306 1
R594 9405 9406 1
R595 9505 9506 1
R596 9605 9606 1
R597 9705 9706 1
R598 9805 9806 1
R599 9905 9906 1
R600 6 7 1
R601 106 107 1
R602 206 207 1
R603 306 307 1
R604 406 407 1
R605 506 507 1
R606 606 607 1
R607 706 707 1
R608 806 807 1
R609 906 907 1
R610 1006 1007 1
R611 1106 1107 1
R612 1206 1207 1
R613 1306 1307 1
R614 1406 1407 1
R615 1506 1507 1
R616 1606 1607 1
R617 1706 1707 1
R618 1806 1807 1
R619 1906 1907 1
R620 2006 2007 1
R621 2106 2107 1
R622 2206 2207 1
R623 2306 2307 1
R624 2406 2407 1
R625 2506 2507 1
R626 2606 2607 1
R627 2706 2707 1
R628 2806 2807 1
R629 2906 2907 1
R630 3006 3007 1
R631 3106 3107 1
R632 3206 3207 1
R633 3306 3307 1
R634 3406 3407 1
R635 3506 3507 1
R636 3606 3607 1
R637 3706 3707 1
R638 3806 3807 1
R639 3906 3907 1
R640 4006 4007 1
R641 4106 4107 1
R642 4206 4207 1
R643 4306 4307 1
R644 4406 4407 1
R645 4506 4507 1
R646 4606 4607 1
R647 4706 4707 1
R648 4806 4807 1
R649 4906 4907 1
R650 5006 5007 1
R651 5106 5107 1
R652 5206 5207 1
R653 5306 5307 1
R654 5406 5407 1
R655 5506 5507 1
R656 5606 5607 1
R657 5706 5707 1
R658 5806 5807 1
R659 5906 5907 1
R660 6006 6007 1
R661 6106 6107 1
R662 6206 6207 1
R663 6306 6307 1
R664 6406 6407 1
R665 6506 6507 1
R666 6606 6607 1
R667 6706 6707 1
R668 6806 6807 1
R669 6906 6907 1
R670 7006 7007 1
R671 7106 7107 1
R672 7206 7207 1
R673 7306 7307 1
R674 7406 7407 1
R675 7506 7507 1
R676 7606 7607 1
R677 7706 7707 1
R678 7806 7807 1
R679 7906 7907 1
R680 8006 8007 1
R681 8106 8107 1
R682 8206 8207 1
R683 8306 8307 1
R684 8406 8407 1
R685 8506 8507 1
R686 8606 8607 1
R687 8706 8707 1
R688 8806 8807 1
R689 8906 8907 1
R690 9006 9007 1
R691 9106 9107 1
R692 9206 9207 1
R693 9306 9307 1
R694 9406 9407 1
R695 9506 9507 1
R696 9606 9607 1
R697 9706 9707 1
R698 9806 9807 1
R699 9906 9907 1
R700 7 8 1
R701 107 108 1
R702 207 208 1
R703 307 308 1
R704 407 408 1
R705 507 508 1
R706 607 608 1
R707 707 708 1
R708 807 808 1
R709 907 908 1
R710 1007 1008 1
R711 1107 1108 1
R712 1207 1208 1
R713 1307 1308 1
R714 1407 1408 1
R715 1507 1508 1
R716 1607 1608 1
R717 1707 1708 1
R718 1807 1808 1
R719 1907 1908 1
R720 2007 2008 1
R721 2107 2108 1
R722 2207 2208 1
R723 2307 2308 1
R724 2407 2408 1
R725 2507 2508 1
R726 2607 2608 1
R727 2707 2708 1
R728 2807 2808 1
R729 2907 2908 1
R730 3007 3008 1
R731 3107 3108 1
R732 3207 3208 1
R733 3307 3308 1
R734 3407 3408 1
R735 3507 3508 1
R736 3607 3608 1
R737 3707 3708 1
R738 3807 3808 1
R739 3907 3908 1
R740 4007 4008 1
R741 4107 4108 1
R742 4207 4208 1
R743 4307 4308 1
R744 4407 4408 1
R745 4507 4508 1
R746 4607 4608 1
R747 4707 4708 1
R748 4807 4808 1
R749 4907 4908 1
R750 5007 5008 1
R751 5107 5108 1
R752 5207 5208 1
R753 5307 5308 1
R754 5407 5408 1
R755 5507 5508 1
R756 5607 5608 1
R757 5707 5708 1
R758 5807 5808 1
R759 5907 5908 1
R760 6007 6008 1
R761 6107 6108 1
R762 6207 6208 1
R763 6307 6308 1
R764 6407 6408 1
R765 6507 6508 1
R766 6607 6608 1
R767 6707 6708 1
R768 6807 6808 1
R769 6907 6908 1
R770 7007 7008 1
R771 7107 7108 1
R772 7207 7208 1
R773 7307 7308 1
R774 7407 7408 1
R775 7507 7508 1
R776 7607 7608 1
R777 7707 7708 1
R778 7807 7808 1
R779 7907 7908 1
R780 8007 8008 1
R781 8107 8108 1
R782 8207 8208 1
R783 8307 8308 1
R784 8407 8408 1
R785 8507 8508 1
R786 8607 8608 1
R787 8707 8708 1
R788 8807 8808 1
R789 8907 8908 1
R790 9007 9008 1
R791 9107 9108 1
R792 9207 9208 1
R793 9307 9308 1
R794 9407 9408 1
R795 9507 9508 1
R796 9607 9608 1
R797 9707 9708 1
R798 9807 9808 1
R799 9907 9908 1
R800 8 9 1
R801 108 109 1
R802 208 209 1
R803 308 309 1
R804 408 409 1
R805 508 509 1
R806 608 609 1
R807 708 709 1
R808 808 809 1
R809 908 909 1
R810 1008 1009 1
R811 1108 1109 1
R812 1208 1209 1
R813 1308 1309 1
R814 1408 1409 1
R815 1508 1509 1
R816 1608 1609 1
R817 1708 1709 1
R818 1808 1809 1
R819 1908 1909 1
R820 2008 2009 1
R821 2108 2109 1
R822 2208 2209 1
R823 2308 2309 1
R824 2408 2409 1
R825 2508 2509 1
R826 2608 2609 1
R827 2708 2709 1
R828 2808 2809 1
R829 2908 2909 1
R830 3008 3009 1
R831 3108 3109 1
R832 3208 3209 1
R833 3308 3309 1
R834 3408 3409 1
R835 3508 3509 1
R836 3608 3609 1
R837 3708 3709 1
R838 3808 3809 1
R839 3908 3909 1
R840 4008 4009 1
R841 4108 4109 1
R842 4208 4209 1
R843 4308 4309 1
R844 4408 4409 1
R845 4508 4509 1
R846 4608 4609 1
R847 4708 4709 1
R848 4808 4809 1
R849 4908 4909 1
R850 5008 5009 1
R851 5108 5109 1
R852 5208 5209 1
R853 5308 5309 1
R854 5408 5409 1
R855 5508 5509 1
R856 5608 5609 1
R857 5708 5709 1
R858 5808 5809 1
R859 5908 5909 1
R860 6008 6009 1
R861 6108 6109 1
R862 6208 6209 1
R863 6308 6309 1
R864 6408 6409 1
R865 6508 6509 1
R866 6608 6609 1
R867 6708 6709 1
R868 6808 6809 1
R869 6908 6909 1
R870 7008 7009 1
R871 7108 7109 1
R872 7208 7209 1
R873 7308 7309 1
R874 7408 7409 1
R875 7508 7509 1
R876 7608 7609 1
R877 7708 7709 1
R878 7808 7809 1
R879 7908 7909 1
R880 8008 8009 1
R881 8108 8109 1
R882 8208 8209 1
R883 8308 8309 1
R884 8408 8409 1
R885 8508 8509 1
R886 8608 8609 1
R887 8708 8709 1
R888 8808 8809 1
R889 8908 8909 1
R890 9008 9009 1
R891 9108 9109 1
R892 9208 9209 1
R893 9308 9309 1
R894 9408 9409 1
R895 9508 9509 1
R896 9608 9609 1
R897 9708 9709 1
R898 9808 9809 1
R899 9908 9909 1
R900 9 10 1
R901 109 110 1
R902 209 210 1
R903 309 310 1
R904 409 410 1
R905 509 510 1
R906 609 610 1
R907 709 710 1
R908 809 810 1
R909 909 910 1
R910 1009 1010 1
R911 1109 1110 1
R912 1209 1210 1
R913 1309 1310 1
R914 1409 1410 1
R915 1509 1510 1
R916 1609 1610 1
R917 1709 1710 1
R918 1809 1810 1
R919 1909 1910 1
R920 2009 2010 1
R921 2109 2110 1
R922 2209 2210 1
R923 2309 2310 1
R924 2409 2410 1
R925 2509 2510 1
R926 2609 2610 1
R927 2709 2710 1
R928 2809 2810 1
R929 2909 2910 1
R930 3009 3010 1
R931 3109 3110 1
R932 3209 3210 1
R933 3309 3310 1
R934 3409 3410 1
R935 3509 3510 1
R936 3609 3610 1
R937 3709 3710 1
R938 3809 3810 1
R939 3909 3910 1
R940 4009 4010 1
R941 4109 4110 1
R942 4209 4210 1
R943 4309 4310 1
R944 4409 4410 1
R945 4509 4510 1
R946 4609 4610 1
R947 4709 4710 1
R948 4809 4810 1
R949 4909 4910 1
R950 5009 5010 1
R951 5109 5110 1
R952 5209 5210 1
R953 5309 5310 1
R954 5409 5410 1
R955 5509 5510 1
R956 5609 5610 1
R957 5709 5710 1
R958 5809 5810 1
R959 5909 5910 1
R960 6009 6010 1
R961 6109 6110 1
R962 6209 6210 1
R963 6309 6310 1
R964 6409 6410 1
R965 6509 6510 1
R966 6609 6610 1
R967 6709 6710 1
R968 6809 6810 1
R969 6909 6910 1
R970 7009 7010 1
R971 7109 7110 1
R972 7209 7210 1
R973 7309 7310 1
R974 7409 7410 1
R975 7509 7510 1
R976 7609 7610 1
R977 7709 7710 1
R978 7809 7810 1
R979 7909 7910 1
R980 8009 8010 1
R981 8109 8110 1
R982 8209 8210 1
R983 8309 8310 1
R984 8409 8410 1
R985 8509 8510 1
R986 8609 8610 1
R987 8709 8710 1
R988 8809 8810 1
R989 8909 8910 1
R990 9009 9010 1
R991 9109 9110 1
R992 9209 9210 1
R993 9309 9310 1
R994 9409 9410 1
R995 9509 9510 1
R996 9609 9610 1
R997 9709 9710 1
R998 9809 9810 1
R999 9909 9910 1
R1000 10 11 1
R1001 110 111 1
R1002 210 211 1
R1003 310 311 1
R1004 410 411 1
R1005 510 511 1
R1006 610 611 1
R1007 710 711 1
R1008 810 811 1
R1009 910 911 1
R1010 1010 1011 1
R1011 1110 1111 1
R1012 1210 1211 1
R1013 1310 1311 1
R1014 1410 1411 1
R1015 1510 1511 1
R1016 1610 1611 1
R1017 1710 1711 1
R1018 1810 1811 1
R1019 1910 1911 1
R1020 2010 2011 1
R1021 2110 2111 1
R1022 2210 2211 1
R1023 2310 2311 1
R1024 2410 2411 1
R1025 2510 2511 1
R1026 2610 2611 1
R1027 2710 2711 1
R1028 2810 2811 1
R1029 2910 2911 1
R1030 3010 3011 1
R1031 3110 3111 1
R1032 3210 3211 1
R1033 3310 3311 1
R1034 3410 3411 1
R1035 3510 3511 1
R1036 3610 3611 1
R1037 3710 3711 1
R1038 3810 3811 1
R1039 3910 3911 1
R1040 4010 4011 1
R1041 4110 4111 1
R1042 4210 4211 1
R1043 4310 4311 1
R1044 4410 4411 1
R1045 4510 4511 1
R1046 4610 4611 1
R1047 4710 4711 1
R1048 4810 4811 1
R1049 4910 4911 1
R1050 5010 5011 1
R1051 5110 5111 1
R1052 5210 5211 1
R1053 5310 5311 1
R1054 5410 5411 1
R1055 5510 5511 1
R1056 5610 5611 1
R1057 5710 5711 1
R1058 5810 5811 1
R1059 5910 5911 1
R1060 6010 6011 1
R1061 6110 6111 1
R1062 6210 6211 1
R1063 6310 6311 1
R1064 6410 6411 1
R1065 6510 6511 1
R1066 6610 6611 1
R1067 6710 6711 1
R1068 6810 6811 1
R1069 6910 6911 1
R1070 7010 7011 1
R1071 7110 7111 1
R1072 7210 7211 1
R1073 7310 7311 1
R1074 7410 7411 1
R1075 7510 7511 1
R1076 7610 7611 1
R1077 7710 7711 1
R1078 7810 7811 1
R1079 7910 7911 1
R1080 8010 8011 1
R1081 8110 8111 1
R1082 8210 8211 1
R1083 8310 8311 1
R1084 8410 8411 1
R1085 8510 8511 1
R1086 8610 8611 1
R1087 8710 8711 1
R1088 8810 8811 1
R1089 8910 8911 1
R1090 9010 9011 1
R1091 9110 9111 1
R1092 9210 9211 1
R1093 9310 9311 1
R1094 9410 9411 1
R1095 9510 9511 1
R1096 9610 9611 1
R1097 9710 9711 1
R1098 9810 9811 1
R1099 9910 9911 1
R1100 11 12 1
R1101 111 112 1
R1102 211 212 1
R1103 311 312 1
R1104 411 412 1
R1105 511 512 1
R1106 611 612 1
R1107 711 712 1
R1108 811 812 1
R1109 911 912 1
R1110 1011 1012 1
R1111 1111 1112 1
R1112 1211 1212 1
R1113 1311 1312 1
R1114 1411 1412 1
R1115 1511 1512 1
R1116 1611 1612 1
R1117 1711 1712 1
R1118 1811 1812 1
R1119 1911 1912 1
R1120 2011 2012 1
R1121 2111 2112 1
R1122 2211 2212 1
R1123 2311 2312 1
R1124 2411 2412 1
R1125 2511 2512 1
R1126 2611 2612 1
R1127 2711 2712 1
R1128 2811 2812 1
R1129 2911 2912 1
R1130 3011 3012 1
R1131 3111 3112 1
R1132 3211 3212 1
R1133 3311 3312 1
R1134 3411 3412 1
R1135 3511 3512 1
R1136 3611 3612 1
R1137 3711 3712 1
R1138 3811 3812 1
R1139 3911 3912 1
R1140 4011 4012 1
R1141 4111 4112 1
R1142 4211 4212 1
R1143 4311 4312 1
R1144 4411 4412 1
R1145 4511 4512 1
R1146 4611 4612 1
R1147 4711 4712 1
R1148 4811 4812 1
R1149 4911 4912 1
R1150 5011 5012 1
R1151 5111 5112 1
R1152 5211 5212 1
R1153 5311 5312 1
R1154 5411 5412 1
R1155 5511 5512 1
R1156 5611 5612 1
R1157 5711 5712 1
R1158 5811 5812 1
R1159 5911 5912 1
R1160 6011 6012 1
R1161 6111 6112 1
R1162 6211 6212 1
R1163 6311 6312 1
R1164 6411 6412 1
R1165 6511 6512 1
R1166 6611 6612 1
R1167 6711 6712 1
R1168 6811 6812 1
R1169 6911 6912 1
R1170 7011 7012 1
R1171 7111 7112 1
R1172 7211 7212 1
R1173 7311 7312 1
R1174 7411 7412 1
R1175 7511 7512 1
R1176 7611 7612 1
R1177 7711 7712 1
R1178 7811 7812 1
R1179 7911 7912 1
R1180 8011 8012 1
R1181 8111 8112 1
R1182 8211 8212 1
R1183 8311 8312 1
R1184 8411 8412 1
R1185 8511 8512 1
R1186 8611 8612 1
R1187 8711 8712 1
R1188 8811 8812 1
R1189 8911 8912 1
R1190 9011 9012 1
R1191 9111 9112 1
R1192 9211 9212 1
R1193 9311 9312 1
R1194 9411 9412 1
R1195 9511 9512 1
R1196 9611 9612 1
R1197 9711 9712 1
R1198 9811 9812 1
R1199 9911 9912 1
R1200 12 13 1
R1201 112 113 1
R1202 212 213 1
R1203 312 313 1
R1204 412 413 1
R1205 512 513 1
R1206 612 613 1
R1207 712 713 1
R1208 812 813 1
R1209 912 913 1
R1210 1012 1013 1
R1211 1112 1113 1
R1212 1212 1213 1
R1213 1312 1313 1
R1214 1412 1413 1
R1215 1512 1513 1
R1216 1612 1613 1
R1217 1712 1713 1
R1218 1812 1813 1
R1219 1912 1913 1
R1220 2012 2013 1
R1221 2112 2113 1
R1222 2212 2213 1
R1223 2312 2313 1
R1224 2412 2413 1
R1225 2512 2513 1
R1226 2612 2613 1
R1227 2712 2713 1
R1228 2812 2813 1
R1229 2912 2913 1
R1230 3012 3013 1
R1231 3112 3113 1
R1232 3212 3213 1
R1233 3312 3313 1
R1234 3412 3413 1
R1235 3512 3513 1
R1236 3612 3613 1
R1237 3712 3713 1
R1238 3812 3813 1
R1239 3912 3913 1
R1240 4012 4013 1
R1241 4112 4113 1
R1242 4212 4213 1
R1243 4312 4313 1
R1244 4412 4413 1
R1245 4512 4513 1
R1246 4612 4613 1
R1247 4712 4713 1
R1248 4812 4813 1
R1249 4912 4913 1
R1250 5012 5013 1
R1251 5112 5113 1
R1252 5212 5213 1
R1253 5312 5313 1
R1254 5412 5413 1
R1255 5512 5513 1
R1256 5612 5613 1
R1257 5712 5713 1
R1258 5812 5813 1
R1259 5912 5913 1
R1260 6012 6013 1
R1261 6112 6113 1
R1262 6212 6213 1
R1263 6312 6313 1
R1264 6412 6413 1
R1265 6512 6513 1
R1266 6612 6613 1
R1267 6712 6713 1
R1268 6812 6813 1
R1269 6912 6913 1
R1270 7012 7013 1
R1271 7112 7113 1
R1272 7212 7213 1
R1273 7312 7313 1
R1274 7412 7413 1
R1275 7512 7513 1
R1276 7612 7613 1
R1277 7712 7713 1
R1278 7812 7813 1
R1279 7912 7913 1
R1280 8012 8013 1
R1281 8112 8113 1
R1282 8212 8213 1
R1283 8312 8313 1
R1284 8412 8413 1
R1285 8512 8513 1
R1286 8612 8613 1
R1287 8712 8713 1
R1288 8812 8813 1
R1289 8912 8913 1
R1290 9012 9013 1
R1291 9112 9113 1
R1292 9212 9213 1
R1293 9312 9313 1
R1294 9412 9413 1
R1295 9512 9513 1
R1296 9612 9613 1
R1297 9712 9713 1
R1298 9812 9813 1
R1299 9912 9913 1
R1300 13 14 1
R1301 113 114 1
R1302 213 214 1
R1303 313 314 1
R1304 413 414 1
R1305 513 514 1
R1306 613 614 1
R1307 713 714 1
R1308 813 814 1
R1309 913 914 1
R1310 1013 1014 1
R1311 1113 1114 1
R1312 1213 1214 1
R1313 1313 1314 1
R1314 1413 1414 1
R1315 1513 1514 1
R1316 1613 1614 1
R1317 1713 1714 1
R1318 1813 1814 1
R1319 1913 1914 1
R1320 2013 2014 1
R1321 2113 2114 1
R1322 2213 2214 1
R1323 2313 2314 1
R1324 2413 2414 1
R1325 2513 2514 1
R1326 2613 2614 1
R1327 2713 2714 1
R1328 2813 2814 1
R1329 2913 2914 1
R1330 3013 3014 1
R1331 3113 3114 1
R1332 3213 3214 1
R1333 3313 3314 1
R1334 3413 3414 1
R1335 3513 3514 1
R1336 3613 3614 1
R1337 3713 3714 1
R1338 3813 3814 1
R1339 3913 3914 1
R1340 4013 4014 1
R1341 4113 4114 1
R1342 4213 4214 1
R1343 4313 4314 1
R1344 4413 4414 1
R1345 4513 4514 1
R1346 4613 4614 1
R1347 4713 4714 1
R1348 4813 4814 1
R1349 4913 4914 1
R1350 5013 5014 1
R1351 5113 5114 1
R1352 5213 5214 1
R1353 5313 5314 1
R1354 5413 5414 1
R1355 5513 5514 1
R1356 5613 5614 1
R1357 5713 5714 1
R1358 5813 5814 1
R1359 5913 5914 1
R1360 6013 6014 1
R1361 6113 6114 1
R1362 6213 6214 1
R1363 6313 6314 1
R1364 6413 6414 1
R1365 6513 6514 1
R1366 6613 6614 1
R1367 6713 6714 1
R1368 6813 6814 1
R1369 6913 6914 1
R1370 7013 7014 1
R1371 7113 7114 1
R1372 7213 7214 1
R1373 7313 7314 1
R1374 7413 7414 1
R1375 7513 7514 1
R1376 7613 7614 1
R1377 7713 7714 1
R1378 7813 7814 1
R1379 7913 7914 1
R1380 8013 8014 1
R1381 8113 8114 1
R1382 8213 8214 1
R1383 8313 8314 1
R1384 8413 8414 1
R1385 8513 8514 1
R1386 8613 8614 1
R1387 8713 8714 1
R1388 8813 8814 1
R1389 8913 8914 1
R1390 9013 9014 1
R1391 9113 9114 1
R1392 9213 9214 1
R1393 9313 9314 1
R1394 9413 9414 1
R1395 9513 9514 1
R1396 9613 9614 1
R1397 9713 9714 1
R1398 9813 9814 1
R1399 9913 9914 1
R1400 14 15 1
R1401 114 115 1
R1402 214 215 1
R1403 314 315 1
R1404 414 415 1
R1405 514 515 1
R1406 614 615 1
R1407 714 715 1
R1408 814 815 1
R1409 914 915 1
R1410 1014 1015 1
R1411 1114 1115 1
R1412 1214 1215 1
R1413 1314 1315 1
R1414 1414 1415 1
R1415 1514 1515 1
R1416 1614 1615 1
R1417 1714 1715 1
R1418 1814 1815 1
R1419 1914 1915 1
R1420 2014 2015 1
R1421 2114 2115 1
R1422 2214 2215 1
R1423 2314 2315 1
R1424 2414 2415 1
R1425 2514 2515 1
R1426 2614 2615 1
R1427 2714 2715 1
R1428 2814 2815 1
R1429 2914 2915 1
R1430 3014 3015 1
R1431 3114 3115 1
R1432 3214 3215 1
R1433 3314 3315 1
R1434 3414 3415 1
R1435 3514 3515 1
R1436 3614 3615 1
R1437 3714 3715 1
R1438 3814 3815 1
R1439 3914 3915 1
R1440 4014 4015 1
R1441 4114 4115 1
R1442 4214 4215 1
R1443 4314 4315 1
R1444 4414 4415 1
R1445 4514 4515 1
R1446 4614 4615 1
R1447 4714 4715 1
R1448 4814 4815 1
R1449 4914 4915 1
R1450 5014 5015 1
R1451 5114 5115 1
R1452 5214 5215 1
R1453 5314 5315 1
R1454 5414 5415 1
R1455 5514 5515 1
R1456 5614 5615 1
R1457 5714 5715 1
R1458 5814 5815 1
R1459 5914 5915 1
R1460 6014 6015 1
R1461 6114 6115 1
R1462 6214 6215 1
R1463 6314 6315 1
R1464 6414 6415 1
R1465 6514 6515 1
R1466 6614 6615 1
R1467 6714 6715 1
R1468 6814 6815 1
R1469 6914 6915 1
R1470 7014 7015 1
R1471 7114 7115 1
R1472 7214 7215 1
R1473 7314 7315 1
R1474 7414 7415 1
R1475 7514 7515 1
R1476 7614 7615 1
R1477 7714 7715 1
R1478 7814 7815 1
R1479 7914 7915 1
R1480 8014 8015 1
R1481 8114 8115 1
R1482 8214 8215 1
R1483 8314 8315 1
R1484 8414 8415 1
R1485 8514 8515 1
R1486 8614 8615 1
R1487 8714 8715 1
R1488 8814 8815 1
R1489 8914 8915 1
R1490 9014 9015 1
R1491 9114 9115 1
R1492 9214 9215 1
R1493 9314 9315 1
R1494 9414 9415 1
R1495 9514 9515 1
R1496 9614 9615 1
R1497 9714 9715 1
R1498 9814 9815 1
R1499 9914 9915 1
R1500 15 16 1
R1501 115 116 1
R1502 215 216 1
R1503 315 316 1
R1504 415 416 1
R1505 515 516 1
R1506 615 616 1
R1507 715 716 1
R1508 815 816 1
R1509 915 916 1
R1510 1015 1016 1
R1511 1115 1116 1
R1512 1215 1216 1
R1513 1315 1316 1
R1514 1415 1416 1
R1515 1515 1516 1
R1516 1615 1616 1
R1517 1715 1716 1
R1518 1815 1816 1
R1519 1915 1916 1
R1520 2015 2016 1
R1521 2115 2116 1
R1522 2215 2216 1
R1523 2315 2316 1
R1524 2415 2416 1
R1525 2515 2516 1
R1526 2615 2616 1
R1527 2715 2716 1
R1528 2815 2816 1
R1529 2915 2916 1
R1530 3015 3016 1
R1531 3115 3116 1
R1532 3215 3216 1
R1533 3315 3316 1
R1534 3415 3416 1
R1535 3515 3516 1
R1536 3615 3616 1
R1537 3715 3716 1
R1538 3815 3816 1
R1539 3915 3916 1
R1540 4015 4016 1
R1541 4115 4116 1
R1542 4215 4216 1
R1543 4315 4316 1
R1544 4415 4416 1
R1545 4515 4516 1
R1546 4615 4616 1
R1547 4715 4716 1
R1548 4815 4816 1
R1549 4915 4916 1
R1550 5015 5016 1
R1551 5115 5116 1
R1552 5215 5216 1
R1553 5315 5316 1
R1554 5415 5416 1
R1555 5515 5516 1
R1556 5615 5616 1
R1557 5715 5716 1
R1558 5815 5816 1
R1559 5915 5916 1
R1560 6015 6016 1
R1561 6115 6116 1
R1562 6215 6216 1
R1563 6315 6316 1
R1564 6415 6416 1
R1565 6515 6516 1
R1566 6615 6616 1
R1567 6715 6716 1
R1568 6815 6816 1
R1569 6915 6916 1
R1570 7015 7016 1
R1571 7115 7116 1
R1572 7215 7216 1
R1573 7315 7316 1
R1574 7415 7416 1
R1575 7515 7516 1
R1576 7615 7616 1
R1577 7715 7716 1
R1578 7815 7816 1
R1579 7915 7916 1
R1580 8015 8016 1
R1581 8115 8116 1
R1582 8215 8216 1
R1583 8315 8316 1
R1584 8415 8416 1
R1585 8515 8516 1
R1586 8615 8616 1
R1587 8715 8716 1
R1588 8815 8816 1
R1589 8915 8916 1
R1590 9015 9016 1
R1591 9115 9116 1
R1592 9215 9216 1
R1593 9315 9316 1
R1594 9415 9416 1
R1595 9515 9516 1
R1596 9615 9616 1
R1597 9715 9716 1
R1598 9815 9816 1
R1599 9915 9916 1
R1600 16 17 1
R1601 116 117 1
R1602 216 217 1
R1603 316 317 1
R1604 416 417 1
R1605 516 517 1
R1606 616 617 1
R1607 716 717 1
R1608 816 817 1
R1609 916 917 1
R1610 1016 1017 1
R1611 1116 1117 1
R1612 1216 1217 1
R1613 1316 1317 1
R1614 1416 1417 1
R1615 1516 1517 1
R1616 1616 1617 1
R1617 1716 1717 1
R1618 1816 1817 1
R1619 1916 1917 1
R1620 2016 2017 1
R1621 2116 2117 1
R1622 2216 2217 1
R1623 2316 2317 1
R1624 2416 2417 1
R1625 2516 2517 1
R1626 2616 2617 1
R1627 2716 2717 1
R1628 2816 2817 1
R1629 2916 2917 1
R1630 3016 3017 1
R1631 3116 3117 1
R1632 3216 3217 1
R1633 3316 3317 1
R1634 3416 3417 1
R1635 3516 3517 1
R1636 3616 3617 1
R1637 3716 3717 1
R1638 3816 3817 1
R1639 3916 3917 1
R1640 4016 4017 1
R1641 4116 4117 1
R1642 4216 4217 1
R1643 4316 4317 1
R1644 4416 4417 1
R1645 4516 4517 1
R1646 4616 4617 1
R1647 4716 4717 1
R1648 4816 4817 1
R1649 4916 4917 1
R1650 5016 5017 1
R1651 5116 5117 1
R1652 5216 5217 1
R1653 5316 5317 1
R1654 5416 5417 1
R1655 5516 5517 1
R1656 5616 5617 1
R1657 5716 5717 1
R1658 5816 5817 1
R1659 5916 5917 1
R1660 6016 6017 1
R1661 6116 6117 1
R1662 6216 6217 1
R1663 6316 6317 1
R1664 6416 6417 1
R1665 6516 6517 1
R1666 6616 6617 1
R1667 6716 6717 1
R1668 6816 6817 1
R1669 6916 6917 1
R1670 7016 7017 1
R1671 7116 7117 1
R1672 7216 7217 1
R1673 7316 7317 1
R1674 7416 7417 1
R1675 7516 7517 1
R1676 7616 7617 1
R1677 7716 7717 1
R1678 7816 7817 1
R1679 7916 7917 1
R1680 8016 8017 1
R1681 8116 8117 1
R1682 8216 8217 1
R1683 8316 8317 1
R1684 8416 8417 1
R1685 8516 8517 1
R1686 8616 8617 1
R1687 8716 8717 1
R1688 8816 8817 1
R1689 8916 8917 1
R1690 9016 9017 1
R1691 9116 9117 1
R1692 9216 9217 1
R1693 9316 9317 1
R1694 9416 9417 1
R1695 9516 9517 1
R1696 9616 9617 1
R1697 9716 9717 1
R1698 9816 9817 1
R1699 9916 9917 1
R1700 17 18 1
R1701 117 118 1
R1702 217 218 1
R1703 317 318 1
R1704 417 418 1
R1705 517 518 1
R1706 617 618 1
R1707 717 718 1
R1708 817 818 1
R1709 917 918 1
R1710 1017 1018 1
R1711 1117 1118 1
R1712 1217 1218 1
R1713 1317 1318 1
R1714 1417 1418 1
R1715 1517 1518 1
R1716 1617 1618 1
R1717 1717 1718 1
R1718 1817 1818 1
R1719 1917 1918 1
R1720 2017 2018 1
R1721 2117 2118 1
R1722 2217 2218 1
R1723 2317 2318 1
R1724 2417 2418 1
R1725 2517 2518 1
R1726 2617 2618 1
R1727 2717 2718 1
R1728 2817 2818 1
R1729 2917 2918 1
R1730 3017 3018 1
R1731 3117 3118 1
R1732 3217 3218 1
R1733 3317 3318 1
R1734 3417 3418 1
R1735 3517 3518 1
R1736 3617 3618 1
R1737 3717 3718 1
R1738 3817 3818 1
R1739 3917 3918 1
R1740 4017 4018 1
R1741 4117 4118 1
R1742 4217 4218 1
R1743 4317 4318 1
R1744 4417 4418 1
R1745 4517 4518 1
R1746 4617 4618 1
R1747 4717 4718 1
R1748 4817 4818 1
R1749 4917 4918 1
R1750 5017 5018 1
R1751 5117 5118 1
R1752 5217 5218 1
R1753 5317 5318 1
R1754 5417 5418 1
R1755 5517 5518 1
R1756 5617 5618 1
R1757 5717 5718 1
R1758 5817 5818 1
R1759 5917 5918 1
R1760 6017 6018 1
R1761 6117 6118 1
R1762 6217 6218 1
R1763 6317 6318 1
R1764 6417 6418 1
R1765 6517 6518 1
R1766 6617 6618 1
R1767 6717 6718 1
R1768 6817 6818 1
R1769 6917 6918 1
R1770 7017 7018 1
R1771 7117 7118 1
R1772 7217 7218 1
R1773 7317 7318 1
R1774 7417 7418 1
R1775 7517 7518 1
R1776 7617 7618 1
R1777 7717 7718 1
R1778 7817 7818 1
R1779 7917 7918 1
R1780 8017 8018 1
R1781 8117 8118 1
R1782 8217 8218 1
R1783 8317 8318 1
R1784 8417 8418 1
R1785 8517 8518 1
R1786 8617 8618 1
R1787 8717 8718 1
R1788 8817 8818 1
R1789 8917 8918 1
R1790 9017 9018 1
R1791 9117 9118 1
R1792 9217 9218 1
R1793 9317 9318 1
R1794 9417 9418 1
R1795 9517 9518 1
R1796 9617 9618 1
R1797 9717 9718 1
R1798 9817 9818 1
R1799 9917 9918 1
R1800 18 19 1
R1801 118 119 1
R1802 218 219 1
R1803 318 319 1
R1804 418 419 1
R1805 518 519 1
R1806 618 619 1
R1807 718 719 1
R1808 818 819 1
R1809 918 919 1
R1810 1018 1019 1
R1811 1118 1119 1
R1812 1218 1219 1
R1813 1318 1319 1
R1814 1418 1419 1
R1815 1518 1519 1
R1816 1618 1619 1
R1817 1718 1719 1
R1818 1818 1819 1
R1819 1918 1919 1
R1820 2018 2019 1
R1821 2118 2119 1
R1822 2218 2219 1
R1823 2318 2319 1
R1824 2418 2419 1
R1825 2518 2519 1
R1826 2618 2619 1
R1827 2718 2719 1
R1828 2818 2819 1
R1829 2918 2919 1
R1830 3018 3019 1
R1831 3118 3119 1
R1832 3218 3219 1
R1833 3318 3319 1
R1834 3418 3419 1
R1835 3518 3519 1
R1836 3618 3619 1
R1837 3718 3719 1
R1838 3818 3819 1
R1839 3918 3919 1
R1840 4018 4019 1
R1841 4118 4119 1
R1842 4218 4219 1
R1843 4318 4319 1
R1844 4418 4419 1
R1845 4518 4519 1
R1846 4618 4619 1
R1847 4718 4719 1
R1848 4818 4819 1
R1849 4918 4919 1
R1850 5018 5019 1
R1851 5118 5119 1
R1852 5218 5219 1
R1853 5318 5319 1
R1854 5418 5419 1
R1855 5518 5519 1
R1856 5618 5619 1
R1857 5718 5719 1
R1858 5818 5819 1
R1859 5918 5919 1
R1860 6018 6019 1
R1861 6118 6119 1
R1862 6218 6219 1
R1863 6318 6319 1
R1864 6418 6419 1
R1865 6518 6519 1
R1866 6618 6619 1
R1867 6718 6719 1
R1868 6818 6819 1
R1869 6918 6919 1
R1870 7018 7019 1
R1871 7118 7119 1
R1872 7218 7219 1
R1873 7318 7319 1
R1874 7418 7419 1
R1875 7518 7519 1
R1876 7618 7619 1
R1877 7718 7719 1
R1878 7818 7819 1
R1879 7918 7919 1
R1880 8018 8019 1
R1881 8118 8119 1
R1882 8218 8219 1
R1883 8318 8319 1
R1884 8418 8419 1
R1885 8518 8519 1
R1886 8618 8619 1
R1887 8718 8719 1
R1888 8818 8819 1
R1889 8918 8919 1
R1890 9018 9019 1
R1891 9118 9119 1
R1892 9218 9219 1
R1893 9318 9319 1
R1894 9418 9419 1
R1895 9518 9519 1
R1896 9618 9619 1
R1897 9718 9719 1
R1898 9818 9819 1
R1899 9918 9919 1
R1900 19 20 1
R1901 119 120 1
R1902 219 220 1
R1903 319 320 1
R1904 419 420 1
R1905 519 520 1
R1906 619 620 1
R1907 719 720 1
R1908 819 820 1
R1909 919 920 1
R1910 1019 1020 1
R1911 1119 1120 1
R1912 1219 1220 1
R1913 1319 1320 1
R1914 1419 1420 1
R1915 1519 1520 1
R1916 1619 1620 1
R1917 1719 1720 1
R1918 1819 1820 1
R1919 1919 1920 1
R1920 2019 2020 1
R1921 2119 2120 1
R1922 2219 2220 1
R1923 2319 2320 1
R1924 2419 2420 1
R1925 2519 2520 1
R1926 2619 2620 1
R1927 2719 2720 1
R1928 2819 2820 1
R1929 2919 2920 1
R1930 3019 3020 1
R1931 3119 3120 1
R1932 3219 3220 1
R1933 3319 3320 1
R1934 3419 3420 1
R1935 3519 3520 1
R1936 3619 3620 1
R1937 3719 3720 1
R1938 3819 3820 1
R1939 3919 3920 1
R1940 4019 4020 1
R1941 4119 4120 1
R1942 4219 4220 1
R1943 4319 4320 1
R1944 4419 4420 1
R1945 4519 4520 1
R1946 4619 4620 1
R1947 4719 4720 1
R1948 4819 4820 1
R1949 4919 4920 1
R1950 5019 5020 1
R1951 5119 5120 1
R1952 5219 5220 1
R1953 5319 5320 1
R1954 5419 5420 1
R1955 5519 5520 1
R1956 5619 5620 1
R1957 5719 5720 1
R1958 5819 5820 1
R1959 5919 5920 1
R1960 6019 6020 1
R1961 6119 6120 1
R1962 6219 6220 1
R1963 6319 6320 1
R1964 6419 6420 1
R1965 6519 6520 1
R1966 6619 6620 1
R1967 6719 6720 1
R1968 6819 6820 1
R1969 6919 6920 1
R1970 7019 7020 1
R1971 7119 7120 1
R1972 7219 7220 1
R1973 7319 7320 1
R1974 7419 7420 1
R1975 7519 7520 1
R1976 7619 7620 1
R1977 7719 7720 1
R1978 7819 7820 1
R1979 7919 7920 1
R1980 8019 8020 1
R1981 8119 8120 1
R1982 8219 8220 1
R1983 8319 8320 1
R1984 8419 8420 1
R1985 8519 8520 1
R1986 8619 8620 1
R1987 8719 8720 1
R1988 8819 8820 1
R1989 8919 8920 1
R1990 9019 9020 1
R1991 9119 9120 1
R1992 9219 9220 1
R1993 9319 9320 1
R1994 9419 9420 1
R1995 9519 9520 1
R1996 9619 9620 1
R1997 9719 9720 1
R1998 9819 9820 1
R1999 9919 9920 1
R2000 20 21 1
R2001 120 121 1
R2002 220 221 1
R2003 320 321 1
R2004 420 421 1
R2005 520 521 1
R2006 620 621 1
R2007 720 721 1
R2008 820 821 1
R2009 920 921 1
R2010 1020 1021 1
R2011 1120 1121 1
R2012 1220 1221 1
R2013 1320 1321 1
R2014 1420 1421 1
R2015 1520 1521 1
R2016 1620 1621 1
R2017 1720 1721 1
R2018 1820 1821 1
R2019 1920 1921 1
R2020 2020 2021 1
R2021 2120 2121 1
R2022 2220 2221 1
R2023 2320 2321 1
R2024 2420 2421 1
R2025 2520 2521 1
R2026 2620 2621 1
R2027 2720 2721 1
R2028 2820 2821 1
R2029 2920 2921 1
R2030 3020 3021 1
R2031 3120 3121 1
R2032 3220 3221 1
R2033 3320 3321 1
R2034 3420 3421 1
R2035 3520 3521 1
R2036 3620 3621 1
R2037 3720 3721 1
R2038 3820 3821 1
R2039 3920 3921 1
R2040 4020 4021 1
R2041 4120 4121 1
R2042 4220 4221 1
R2043 4320 4321 1
R2044 4420 4421 1
R2045 4520 4521 1
R2046 4620 4621 1
R2047 4720 4721 1
R2048 4820 4821 1
R2049 4920 4921 1
R2050 5020 5021 1
R2051 5120 5121 1
R2052 5220 5221 1
R2053 5320 5321 1
R2054 5420 5421 1
R2055 5520 5521 1
R2056 5620 5621 1
R2057 5720 5721 1
R2058 5820 5821 1
R2059 5920 5921 1
R2060 6020 6021 1
R2061 6120 6121 1
R2062 6220 6221 1
R2063 6320 6321 1
R2064 6420 6421 1
R2065 6520 6521 1
R2066 6620 6621 1
R2067 6720 6721 1
R2068 6820 6821 1
R2069 6920 6921 1
R2070 7020 7021 1
R2071 7120 7121 1
R2072 7220 7221 1
R2073 7320 7321 1
R2074 7420 7421 1
R2075 7520 7521 1
R2076 7620 7621 1
R2077 7720 7721 1
R2078 7820 7821 1
R2079 7920 7921 1
R2080 8020 8021 1
R2081 8120 8121 1
R2082 8220 8221 1
R2083 8320 8321 1
R2084 8420 8421 1
R2085 8520 8521 1
R2086 8620 8621 1
R2087 8720 8721 1
R2088 8820 8821 1
R2089 8920 8921 1
R2090 9020 9021 1
R2091 9120 9121 1
R2092 9220 9221 1
R2093 9320 9321 1
R2094 9420 9421 1
R2095 9520 9521 1
R2096 9620 9621 1
R2097 9720 9721 1
R2098 9820 9821 1
R2099 9920 9921 1
R2100 21 22 1
R2101 121 122 1
R2102 221 222 1
R2103 321 322 1
R2104 421 422 1
R2105 521 522 1
R2106 621 622 1
R2107 721 722 1
R2108 821 822 1
R2109 921 922 1
R2110 1021 1022 1
R2111 1121 1122 1
R2112 1221 1222 1
R2113 1321 1322 1
R2114 1421 1422 1
R2115 1521 1522 1
R2116 1621 1622 1
R2117 1721 1722 1
R2118 1821 1822 1
R2119 1921 1922 1
R2120 2021 2022 1
R2121 2121 2122 1
R2122 2221 2222 1
R2123 2321 2322 1
R2124 2421 2422 1
R2125 2521 2522 1
R2126 2621 2622 1
R2127 2721 2722 1
R2128 2821 2822 1
R2129 2921 2922 1
R2130 3021 3022 1
R2131 3121 3122 1
R2132 3221 3222 1
R2133 3321 3322 1
R2134 3421 3422 1
R2135 3521 3522 1
R2136 3621 3622 1
R2137 3721 3722 1
R2138 3821 3822 1
R2139 3921 3922 1
R2140 4021 4022 1
R2141 4121 4122 1
R2142 4221 4222 1
R2143 4321 4322 1
R2144 4421 4422 1
R2145 4521 4522 1
R2146 4621 4622 1
R2147 4721 4722 1
R2148 4821 4822 1
R2149 4921 4922 1
R2150 5021 5022 1
R2151 5121 5122 1
R2152 5221 5222 1
R2153 5321 5322 1
R2154 5421 5422 1
R2155 5521 5522 1
R2156 5621 5622 1
R2157 5721 5722 1
R2158 5821 5822 1
R2159 5921 5922 1
R2160 6021 6022 1
R2161 6121 6122 1
R2162 6221 6222 1
R2163 6321 6322 1
R2164 6421 6422 1
R2165 6521 6522 1
R2166 6621 6622 1
R2167 6721 6722 1
R2168 6821 6822 1
R2169 6921 6922 1
R2170 7021 7022 1
R2171 7121 7122 1
R2172 7221 7222 1
R2173 7321 7322 1
R2174 7421 7422 1
R2175 7521 7522 1
R2176 7621 7622 1
R2177 7721 7722 1
R2178 7821 7822 1
R2179 7921 7922 1
R2180 8021 8022 1
R2181 8121 8122 1
R2182 8221 8222 1
R2183 8321 8322 1
R2184 8421 8422 1
R2185 8521 8522 1
R2186 8621 8622 1
R2187 8721 8722 1
R2188 8821 8822 1
R2189 8921 8922 1
R2190 9021 9022 1
R2191 9121 9122 1
R2192 9221 9222 1
R2193 9321 9322 1
R2194 9421 9422 1
R2195 9521 9522 1
R2196 9621 9622 1
R2197 9721 9722 1
R2198 9821 9822 1
R2199 9921 9922 1
R2200 22 23 1
R2201 122 123 1
R2202 222 223 1
R2203 322 323 1
R2204 422 423 1
R2205 522 523 1
R2206 622 623 1
R2207 722 723 1
R2208 822 823 1
R2209 922 923 1
R2210 1022 1023 1
R2211 1122 1123 1
R2212 1222 1223 1
R2213 1322 1323 1
R2214 1422 1423 1
R2215 1522 1523 1
R2216 1622 1623 1
R2217 1722 1723 1
R2218 1822 1823 1
R2219 1922 1923 1
R2220 2022 2023 1
R2221 2122 2123 1
R2222 2222 2223 1
R2223 2322 2323 1
R2224 2422 2423 1
R2225 2522 2523 1
R2226 2622 2623 1
R2227 2722 2723 1
R2228 2822 2823 1
R2229 2922 2923 1
R2230 3022 3023 1
R2231 3122 3123 1
R2232 3222 3223 1
R2233 3322 3323 1
R2234 3422 3423 1
R2235 3522 3523 1
R2236 3622 3623 1
R2237 3722 3723 1
R2238 3822 3823 1
R2239 3922 3923 1
R2240 4022 4023 1
R2241 4122 4123 1
R2242 4222 4223 1
R2243 4322 4323 1
R2244 4422 4423 1
R2245 4522 4523 1
R2246 4622 4623 1
R2247 4722 4723 1
R2248 4822 4823 1
R2249 4922 4923 1
R2250 5022 5023 1
R2251 5122 5123 1
R2252 5222 5223 1
R2253 5322 5323 1
R2254 5422 5423 1
R2255 5522 5523 1
R2256 5622 5623 1
R2257 5722 5723 1
R2258 5822 5823 1
R2259 5922 5923 1
R2260 6022 6023 1
R2261 6122 6123 1
R2262 6222 6223 1
R2263 6322 6323 1
R2264 6422 6423 1
R2265 6522 6523 1
R2266 6622 6623 1
R2267 6722 6723 1
R2268 6822 6823 1
R2269 6922 6923 1
R2270 7022 7023 1
R2271 7122 7123 1
R2272 7222 7223 1
R2273 7322 7323 1
R2274 7422 7423 1
R2275 7522 7523 1
R2276 7622 7623 1
R2277 7722 7723 1
R2278 7822 7823 1
R2279 7922 7923 1
R2280 8022 8023 1
R2281 8122 8123 1
R2282 8222 8223 1
R2283 8322 8323 1
R2284 8422 8423 1
R2285 8522 8523 1
R2286 8622 8623 1
R2287 8722 8723 1
R2288 8822 8823 1
R2289 8922 8923 1
R2290 9022 9023 1
R2291 9122 9123 1
R2292 9222 9223 1
R2293 9322 9323 1
R2294 9422 9423 1
R2295 9522 9523 1
R2296 9622 9623 1
R2297 9722 9723 1
R2298 9822 9823 1
R2299 9922 9923 1
R2300 23 24 1
R2301 123 124 1
R2302 223 224 1
R2303 323 324 1
R2304 423 424 1
R2305 523 524 1
R2306 623 624 1
R2307 723 724 1
R2308 823 824 1
R2309 923 924 1
R2310 1023 1024 1
R2311 1123 1124 1
R2312 1223 1224 1
R2313 1323 1324 1
R2314 1423 1424 1
R2315 1523 1524 1
R2316 1623 1624 1
R2317 1723 1724 1
R2318 1823 1824 1
R2319 1923 1924 1
R2320 2023 2024 1
R2321 2123 2124 1
R2322 2223 2224 1
R2323 2323 2324 1
R2324 2423 2424 1
R2325 2523 2524 1
R2326 2623 2624 1
R2327 2723 2724 1
R2328 2823 2824 1
R2329 2923 2924 1
R2330 3023 3024 1
R2331 3123 3124 1
R2332 3223 3224 1
R2333 3323 3324 1
R2334 3423 3424 1
R2335 3523 3524 1
R2336 3623 3624 1
R2337 3723 3724 1
R2338 3823 3824 1
R2339 3923 3924 1
R2340 4023 4024 1
R2341 4123 4124 1
R2342 4223 4224 1
R2343 4323 4324 1
R2344 4423 4424 1
R2345 4523 4524 1
R2346 4623 4624 1
R2347 4723 4724 1
R2348 4823 4824 1
R2349 4923 4924 1
R2350 5023 5024 1
R2351 5123 5124 1
R2352 5223 5224 1
R2353 5323 5324 1
R2354 5423 5424 1
R2355 5523 5524 1
R2356 5623 5624 1
R2357 5723 5724 1
R2358 5823 5824 1
R2359 5923 5924 1
R2360 6023 6024 1
R2361 6123 6124 1
R2362 6223 6224 1
R2363 6323 6324 1
R2364 6423 6424 1
R2365 6523 6524 1
R2366 6623 6624 1
R2367 6723 6724 1
R2368 6823 6824 1
R2369 6923 6924 1
R2370 7023 7024 1
R2371 7123 7124 1
R2372 7223 7224 1
R2373 7323 7324 1
R2374 7423 7424 1
R2375 7523 7524 1
R2376 7623 7624 1
R2377 7723 7724 1
R2378 7823 7824 1
R2379 7923 7924 1
R2380 8023 8024 1
R2381 8123 8124 1
R2382 8223 8224 1
R2383 8323 8324 1
R2384 8423 8424 1
R2385 8523 8524 1
R2386 8623 8624 1
R2387 8723 8724 1
R2388 8823 8824 1
R2389 8923 8924 1
R2390 9023 9024 1
R2391 9123 9124 1
R2392 9223 9224 1
R2393 9323 9324 1
R2394 9423 9424 1
R2395 9523 9524 1
R2396 9623 9624 1
R2397 9723 9724 1
R2398 9823 9824 1
R2399 9923 9924 1
R2400 24 25 1
R2401 124 125 1
R2402 224 225 1
R2403 324 325 1
R2404 424 425 1
R2405 524 525 1
R2406 624 625 1
R2407 724 725 1
R2408 824 825 1
R2409 924 925 1
R2410 1024 1025 1
R2411 1124 1125 1
R2412 1224 1225 1
R2413 1324 1325 1
R2414 1424 1425 1
R2415 1524 1525 1
R2416 1624 1625 1
R2417 1724 1725 1
R2418 1824 1825 1
R2419 1924 1925 1
R2420 2024 2025 1
R2421 2124 2125 1
R2422 2224 2225 1
R2423 2324 2325 1
R2424 2424 2425 1
R2425 2524 2525 1
R2426 2624 2625 1
R2427 2724 2725 1
R2428 2824 2825 1
R2429 2924 2925 1
R2430 3024 3025 1
R2431 3124 3125 1
R2432 3224 3225 1
R2433 3324 3325 1
R2434 3424 3425 1
R2435 3524 3525 1
R2436 3624 3625 1
R2437 3724 3725 1
R2438 3824 3825 1
R2439 3924 3925 1
R2440 4024 4025 1
R2441 4124 4125 1
R2442 4224 4225 1
R2443 4324 4325 1
R2444 4424 4425 1
R2445 4524 4525 1
R2446 4624 4625 1
R2447 4724 4725 1
R2448 4824 4825 1
R2449 4924 4925 1
R2450 5024 5025 1
R2451 5124 5125 1
R2452 5224 5225 1
R2453 5324 5325 1
R2454 5424 5425 1
R2455 5524 5525 1
R2456 5624 5625 1
R2457 5724 5725 1
R2458 5824 5825 1
R2459 5924 5925 1
R2460 6024 6025 1
R2461 6124 6125 1
R2462 6224 6225 1
R2463 6324 6325 1
R2464 6424 6425 1
R2465 6524 6525 1
R2466 6624 6625 1
R2467 6724 6725 1
R2468 6824 6825 1
R2469 6924 6925 1
R2470 7024 7025 1
R2471 7124 7125 1
R2472 7224 7225 1
R2473 7324 7325 1
R2474 7424 7425 1
R2475 7524 7525 1
R2476 7624 7625 1
R2477 7724 7725 1
R2478 7824 7825 1
R2479 7924 7925 1
R2480 8024 8025 1
R2481 8124 8125 1
R2482 8224 8225 1
R2483 8324 8325 1
R2484 8424 8425 1
R2485 8524 8525 1
R2486 8624 8625 1
R2487 8724 8725 1
R2488 8824 8825 1
R2489 8924 8925 1
R2490 9024 9025 1
R2491 9124 9125 1
R2492 9224 9225 1
R2493 9324 9325 1
R2494 9424 9425 1
R2495 9524 9525 1
R2496 9624 9625 1
R2497 9724 9725 1
R2498 9824 9825 1
R2499 9924 9925 1
R2500 25 26 1
R2501 125 126 1
R2502 225 226 1
R2503 325 326 1
R2504 425 426 1
R2505 525 526 1
R2506 625 626 1
R2507 725 726 1
R2508 825 826 1
R2509 925 926 1
R2510 1025 1026 1
R2511 1125 1126 1
R2512 1225 1226 1
R2513 1325 1326 1
R2514 1425 1426 1
R2515 1525 1526 1
R2516 1625 1626 1
R2517 1725 1726 1
R2518 1825 1826 1
R2519 1925 1926 1
R2520 2025 2026 1
R2521 2125 2126 1
R2522 2225 2226 1
R2523 2325 2326 1
R2524 2425 2426 1
R2525 2525 2526 1
R2526 2625 2626 1
R2527 2725 2726 1
R2528 2825 2826 1
R2529 2925 2926 1
R2530 3025 3026 1
R2531 3125 3126 1
R2532 3225 3226 1
R2533 3325 3326 1
R2534 3425 3426 1
R2535 3525 3526 1
R2536 3625 3626 1
R2537 3725 3726 1
R2538 3825 3826 1
R2539 3925 3926 1
R2540 4025 4026 1
R2541 4125 4126 1
R2542 4225 4226 1
R2543 4325 4326 1
R2544 4425 4426 1
R2545 4525 4526 1
R2546 4625 4626 1
R2547 4725 4726 1
R2548 4825 4826 1
R2549 4925 4926 1
R2550 5025 5026 1
R2551 5125 5126 1
R2552 5225 5226 1
R2553 5325 5326 1
R2554 5425 5426 1
R2555 5525 5526 1
R2556 5625 5626 1
R2557 5725 5726 1
R2558 5825 5826 1
R2559 5925 5926 1
R2560 6025 6026 1
R2561 6125 6126 1
R2562 6225 6226 1
R2563 6325 6326 1
R2564 6425 6426 1
R2565 6525 6526 1
R2566 6625 6626 1
R2567 6725 6726 1
R2568 6825 6826 1
R2569 6925 6926 1
R2570 7025 7026 1
R2571 7125 7126 1
R2572 7225 7226 1
R2573 7325 7326 1
R2574 7425 7426 1
R2575 7525 7526 1
R2576 7625 7626 1
R2577 7725 7726 1
R2578 7825 7826 1
R2579 7925 7926 1
R2580 8025 8026 1
R2581 8125 8126 1
R2582 8225 8226 1
R2583 8325 8326 1
R2584 8425 8426 1
R2585 8525 8526 1
R2586 8625 8626 1
R2587 8725 8726 1
R2588 8825 8826 1
R2589 8925 8926 1
R2590 9025 9026 1
R2591 9125 9126 1
R2592 9225 9226 1
R2593 9325 9326 1
R2594 9425 9426 1
R2595 9525 9526 1
R2596 9625 9626 1
R2597 9725 9726 1
R2598 9825 9826 1
R2599 9925 9926 1
R2600 26 27 1
R2601 126 127 1
R2602 226 227 1
R2603 326 327 1
R2604 426 427 1
R2605 526 527 1
R2606 626 627 1
R2607 726 727 1
R2608 826 827 1
R2609 926 927 1
R2610 1026 1027 1
R2611 1126 1127 1
R2612 1226 1227 1
R2613 1326 1327 1
R2614 1426 1427 1
R2615 1526 1527 1
R2616 1626 1627 1
R2617 1726 1727 1
R2618 1826 1827 1
R2619 1926 1927 1
R2620 2026 2027 1
R2621 2126 2127 1
R2622 2226 2227 1
R2623 2326 2327 1
R2624 2426 2427 1
R2625 2526 2527 1
R2626 2626 2627 1
R2627 2726 2727 1
R2628 2826 2827 1
R2629 2926 2927 1
R2630 3026 3027 1
R2631 3126 3127 1
R2632 3226 3227 1
R2633 3326 3327 1
R2634 3426 3427 1
R2635 3526 3527 1
R2636 3626 3627 1
R2637 3726 3727 1
R2638 3826 3827 1
R2639 3926 3927 1
R2640 4026 4027 1
R2641 4126 4127 1
R2642 4226 4227 1
R2643 4326 4327 1
R2644 4426 4427 1
R2645 4526 4527 1
R2646 4626 4627 1
R2647 4726 4727 1
R2648 4826 4827 1
R2649 4926 4927 1
R2650 5026 5027 1
R2651 5126 5127 1
R2652 5226 5227 1
R2653 5326 5327 1
R2654 5426 5427 1
R2655 5526 5527 1
R2656 5626 5627 1
R2657 5726 5727 1
R2658 5826 5827 1
R2659 5926 5927 1
R2660 6026 6027 1
R2661 6126 6127 1
R2662 6226 6227 1
R2663 6326 6327 1
R2664 6426 6427 1
R2665 6526 6527 1
R2666 6626 6627 1
R2667 6726 6727 1
R2668 6826 6827 1
R2669 6926 6927 1
R2670 7026 7027 1
R2671 7126 7127 1
R2672 7226 7227 1
R2673 7326 7327 1
R2674 7426 7427 1
R2675 7526 7527 1
R2676 7626 7627 1
R2677 7726 7727 1
R2678 7826 7827 1
R2679 7926 7927 1
R2680 8026 8027 1
R2681 8126 8127 1
R2682 8226 8227 1
R2683 8326 8327 1
R2684 8426 8427 1
R2685 8526 8527 1
R2686 8626 8627 1
R2687 8726 8727 1
R2688 8826 8827 1
R2689 8926 8927 1
R2690 9026 9027 1
R2691 9126 9127 1
R2692 9226 9227 1
R2693 9326 9327 1
R2694 9426 9427 1
R2695 9526 9527 1
R2696 9626 9627 1
R2697 9726 9727 1
R2698 9826 9827 1
R2699 9926 9927 1
R2700 27 28 1
R2701 127 128 1
R2702 227 228 1
R2703 327 328 1
R2704 427 428 1
R2705 527 528 1
R2706 627 628 1
R2707 727 728 1
R2708 827 828 1
R2709 927 928 1
R2710 1027 1028 1
R2711 1127 1128 1
R2712 1227 1228 1
R2713 1327 1328 1
R2714 1427 1428 1
R2715 1527 1528 1
R2716 1627 1628 1
R2717 1727 1728 1
R2718 1827 1828 1
R2719 1927 1928 1
R2720 2027 2028 1
R2721 2127 2128 1
R2722 2227 2228 1
R2723 2327 2328 1
R2724 2427 2428 1
R2725 2527 2528 1
R2726 2627 2628 1
R2727 2727 2728 1
R2728 2827 2828 1
R2729 2927 2928 1
R2730 3027 3028 1
R2731 3127 3128 1
R2732 3227 3228 1
R2733 3327 3328 1
R2734 3427 3428 1
R2735 3527 3528 1
R2736 3627 3628 1
R2737 3727 3728 1
R2738 3827 3828 1
R2739 3927 3928 1
R2740 4027 4028 1
R2741 4127 4128 1
R2742 4227 4228 1
R2743 4327 4328 1
R2744 4427 4428 1
R2745 4527 4528 1
R2746 4627 4628 1
R2747 4727 4728 1
R2748 4827 4828 1
R2749 4927 4928 1
R2750 5027 5028 1
R2751 5127 5128 1
R2752 5227 5228 1
R2753 5327 5328 1
R2754 5427 5428 1
R2755 5527 5528 1
R2756 5627 5628 1
R2757 5727 5728 1
R2758 5827 5828 1
R2759 5927 5928 1
R2760 6027 6028 1
R2761 6127 6128 1
R2762 6227 6228 1
R2763 6327 6328 1
R2764 6427 6428 1
R2765 6527 6528 1
R2766 6627 6628 1
R2767 6727 6728 1
R2768 6827 6828 1
R2769 6927 6928 1
R2770 7027 7028 1
R2771 7127 7128 1
R2772 7227 7228 1
R2773 7327 7328 1
R2774 7427 7428 1
R2775 7527 7528 1
R2776 7627 7628 1
R2777 7727 7728 1
R2778 7827 7828 1
R2779 7927 7928 1
R2780 8027 8028 1
R2781 8127 8128 1
R2782 8227 8228 1
R2783 8327 8328 1
R2784 8427 8428 1
R2785 8527 8528 1
R2786 8627 8628 1
R2787 8727 8728 1
R2788 8827 8828 1
R2789 8927 8928 1
R2790 9027 9028 1
R2791 9127 9128 1
R2792 9227 9228 1
R2793 9327 9328 1
R2794 9427 9428 1
R2795 9527 9528 1
R2796 9627 9628 1
R2797 9727 9728 1
R2798 9827 9828 1
R2799 9927 9928 1
R2800 28 29 1
R2801 128 129 1
R2802 228 229 1
R2803 328 329 1
R2804 428 429 1
R2805 528 529 1
R2806 628 629 1
R2807 728 729 1
R2808 828 829 1
R2809 928 929 1
R2810 1028 1029 1
R2811 1128 1129 1
R2812 1228 1229 1
R2813 1328 1329 1
R2814 1428 1429 1
R2815 1528 1529 1
R2816 1628 1629 1
R2817 1728 1729 1
R2818 1828 1829 1
R2819 1928 1929 1
R2820 2028 2029 1
R2821 2128 2129 1
R2822 2228 2229 1
R2823 2328 2329 1
R2824 2428 2429 1
R2825 2528 2529 1
R2826 2628 2629 1
R2827 2728 2729 1
R2828 2828 2829 1
R2829 2928 2929 1
R2830 3028 3029 1
R2831 3128 3129 1
R2832 3228 3229 1
R2833 3328 3329 1
R2834 3428 3429 1
R2835 3528 3529 1
R2836 3628 3629 1
R2837 3728 3729 1
R2838 3828 3829 1
R2839 3928 3929 1
R2840 4028 4029 1
R2841 4128 4129 1
R2842 4228 4229 1
R2843 4328 4329 1
R2844 4428 4429 1
R2845 4528 4529 1
R2846 4628 4629 1
R2847 4728 4729 1
R2848 4828 4829 1
R2849 4928 4929 1
R2850 5028 5029 1
R2851 5128 5129 1
R2852 5228 5229 1
R2853 5328 5329 1
R2854 5428 5429 1
R2855 5528 5529 1
R2856 5628 5629 1
R2857 5728 5729 1
R2858 5828 5829 1
R2859 5928 5929 1
R2860 6028 6029 1
R2861 6128 6129 1
R2862 6228 6229 1
R2863 6328 6329 1
R2864 6428 6429 1
R2865 6528 6529 1
R2866 6628 6629 1
R2867 6728 6729 1
R2868 6828 6829 1
R2869 6928 6929 1
R2870 7028 7029 1
R2871 7128 7129 1
R2872 7228 7229 1
R2873 7328 7329 1
R2874 7428 7429 1
R2875 7528 7529 1
R2876 7628 7629 1
R2877 7728 7729 1
R2878 7828 7829 1
R2879 7928 7929 1
R2880 8028 8029 1
R2881 8128 8129 1
R2882 8228 8229 1
R2883 8328 8329 1
R2884 8428 8429 1
R2885 8528 8529 1
R2886 8628 8629 1
R2887 8728 8729 1
R2888 8828 8829 1
R2889 8928 8929 1
R2890 9028 9029 1
R2891 9128 9129 1
R2892 9228 9229 1
R2893 9328 9329 1
R2894 9428 9429 1
R2895 9528 9529 1
R2896 9628 9629 1
R2897 9728 9729 1
R2898 9828 9829 1
R2899 9928 9929 1
R2900 29 30 1
R2901 129 130 1
R2902 229 230 1
R2903 329 330 1
R2904 429 430 1
R2905 529 530 1
R2906 629 630 1
R2907 729 730 1
R2908 829 830 1
R2909 929 930 1
R2910 1029 1030 1
R2911 1129 1130 1
R2912 1229 1230 1
R2913 1329 1330 1
R2914 1429 1430 1
R2915 1529 1530 1
R2916 1629 1630 1
R2917 1729 1730 1
R2918 1829 1830 1
R2919 1929 1930 1
R2920 2029 2030 1
R2921 2129 2130 1
R2922 2229 2230 1
R2923 2329 2330 1
R2924 2429 2430 1
R2925 2529 2530 1
R2926 2629 2630 1
R2927 2729 2730 1
R2928 2829 2830 1
R2929 2929 2930 1
R2930 3029 3030 1
R2931 3129 3130 1
R2932 3229 3230 1
R2933 3329 3330 1
R2934 3429 3430 1
R2935 3529 3530 1
R2936 3629 3630 1
R2937 3729 3730 1
R2938 3829 3830 1
R2939 3929 3930 1
R2940 4029 4030 1
R2941 4129 4130 1
R2942 4229 4230 1
R2943 4329 4330 1
R2944 4429 4430 1
R2945 4529 4530 1
R2946 4629 4630 1
R2947 4729 4730 1
R2948 4829 4830 1
R2949 4929 4930 1
R2950 5029 5030 1
R2951 5129 5130 1
R2952 5229 5230 1
R2953 5329 5330 1
R2954 5429 5430 1
R2955 5529 5530 1
R2956 5629 5630 1
R2957 5729 5730 1
R2958 5829 5830 1
R2959 5929 5930 1
R2960 6029 6030 1
R2961 6129 6130 1
R2962 6229 6230 1
R2963 6329 6330 1
R2964 6429 6430 1
R2965 6529 6530 1
R2966 6629 6630 1
R2967 6729 6730 1
R2968 6829 6830 1
R2969 6929 6930 1
R2970 7029 7030 1
R2971 7129 7130 1
R2972 7229 7230 1
R2973 7329 7330 1
R2974 7429 7430 1
R2975 7529 7530 1
R2976 7629 7630 1
R2977 7729 7730 1
R2978 7829 7830 1
R2979 7929 7930 1
R2980 8029 8030 1
R2981 8129 8130 1
R2982 8229 8230 1
R2983 8329 8330 1
R2984 8429 8430 1
R2985 8529 8530 1
R2986 8629 8630 1
R2987 8729 8730 1
R2988 8829 8830 1
R2989 8929 8930 1
R2990 9029 9030 1
R2991 9129 9130 1
R2992 9229 9230 1
R2993 9329 9330 1
R2994 9429 9430 1
R2995 9529 9530 1
R2996 9629 9630 1
R2997 9729 9730 1
R2998 9829 9830 1
R2999 9929 9930 1
R3000 30 31 1
R3001 130 131 1
R3002 230 231 1
R3003 330 331 1
R3004 430 431 1
R3005 530 531 1
R3006 630 631 1
R3007 730 731 1
R3008 830 831 1
R3009 930 931 1
R3010 1030 1031 1
R3011 1130 1131 1
R3012 1230 1231 1
R3013 1330 1331 1
R3014 1430 1431 1
R3015 1530 1531 1
R3016 1630 1631 1
R3017 1730 1731 1
R3018 1830 1831 1
R3019 1930 1931 1
R3020 2030 2031 1
R3021 2130 2131 1
R3022 2230 2231 1
R3023 2330 2331 1
R3024 2430 2431 1
R3025 2530 2531 1
R3026 2630 2631 1
R3027 2730 2731 1
R3028 2830 2831 1
R3029 2930 2931 1
R3030 3030 3031 1
R3031 3130 3131 1
R3032 3230 3231 1
R3033 3330 3331 1
R3034 3430 3431 1
R3035 3530 3531 1
R3036 3630 3631 1
R3037 3730 3731 1
R3038 3830 3831 1
R3039 3930 3931 1
R3040 4030 4031 1
R3041 4130 4131 1
R3042 4230 4231 1
R3043 4330 4331 1
R3044 4430 4431 1
R3045 4530 4531 1
R3046 4630 4631 1
R3047 4730 4731 1
R3048 4830 4831 1
R3049 4930 4931 1
R3050 5030 5031 1
R3051 5130 5131 1
R3052 5230 5231 1
R3053 5330 5331 1
R3054 5430 5431 1
R3055 5530 5531 1
R3056 5630 5631 1
R3057 5730 5731 1
R3058 5830 5831 1
R3059 5930 5931 1
R3060 6030 6031 1
R3061 6130 6131 1
R3062 6230 6231 1
R3063 6330 6331 1
R3064 6430 6431 1
R3065 6530 6531 1
R3066 6630 6631 1
R3067 6730 6731 1
R3068 6830 6831 1
R3069 6930 6931 1
R3070 7030 7031 1
R3071 7130 7131 1
R3072 7230 7231 1
R3073 7330 7331 1
R3074 7430 7431 1
R3075 7530 7531 1
R3076 7630 7631 1
R3077 7730 7731 1
R3078 7830 7831 1
R3079 7930 7931 1
R3080 8030 8031 1
R3081 8130 8131 1
R3082 8230 8231 1
R3083 8330 8331 1
R3084 8430 8431 1
R3085 8530 8531 1
R3086 8630 8631 1
R3087 8730 8731 1
R3088 8830 8831 1
R3089 8930 8931 1
R3090 9030 9031 1
R3091 9130 9131 1
R3092 9230 9231 1
R3093 9330 9331 1
R3094 9430 9431 1
R3095 9530 9531 1
R3096 9630 9631 1
R3097 9730 9731 1
R3098 9830 9831 1
R3099 9930 9931 1
R3100 31 32 1
R3101 131 132 1
R3102 231 232 1
R3103 331 332 1
R3104 431 432 1
R3105 531 532 1
R3106 631 632 1
R3107 731 732 1
R3108 831 832 1
R3109 931 932 1
R3110 1031 1032 1
R3111 1131 1132 1
R3112 1231 1232 1
R3113 1331 1332 1
R3114 1431 1432 1
R3115 1531 1532 1
R3116 1631 1632 1
R3117 1731 1732 1
R3118 1831 1832 1
R3119 1931 1932 1
R3120 2031 2032 1
R3121 2131 2132 1
R3122 2231 2232 1
R3123 2331 2332 1
R3124 2431 2432 1
R3125 2531 2532 1
R3126 2631 2632 1
R3127 2731 2732 1
R3128 2831 2832 1
R3129 2931 2932 1
R3130 3031 3032 1
R3131 3131 3132 1
R3132 3231 3232 1
R3133 3331 3332 1
R3134 3431 3432 1
R3135 3531 3532 1
R3136 3631 3632 1
R3137 3731 3732 1
R3138 3831 3832 1
R3139 3931 3932 1
R3140 4031 4032 1
R3141 4131 4132 1
R3142 4231 4232 1
R3143 4331 4332 1
R3144 4431 4432 1
R3145 4531 4532 1
R3146 4631 4632 1
R3147 4731 4732 1
R3148 4831 4832 1
R3149 4931 4932 1
R3150 5031 5032 1
R3151 5131 5132 1
R3152 5231 5232 1
R3153 5331 5332 1
R3154 5431 5432 1
R3155 5531 5532 1
R3156 5631 5632 1
R3157 5731 5732 1
R3158 5831 5832 1
R3159 5931 5932 1
R3160 6031 6032 1
R3161 6131 6132 1
R3162 6231 6232 1
R3163 6331 6332 1
R3164 6431 6432 1
R3165 6531 6532 1
R3166 6631 6632 1
R3167 6731 6732 1
R3168 6831 6832 1
R3169 6931 6932 1
R3170 7031 7032 1
R3171 7131 7132 1
R3172 7231 7232 1
R3173 7331 7332 1
R3174 7431 7432 1
R3175 7531 7532 1
R3176 7631 7632 1
R3177 7731 7732 1
R3178 7831 7832 1
R3179 7931 7932 1
R3180 8031 8032 1
R3181 8131 8132 1
R3182 8231 8232 1
R3183 8331 8332 1
R3184 8431 8432 1
R3185 8531 8532 1
R3186 8631 8632 1
R3187 8731 8732 1
R3188 8831 8832 1
R3189 8931 8932 1
R3190 9031 9032 1
R3191 9131 9132 1
R3192 9231 9232 1
R3193 9331 9332 1
R3194 9431 9432 1
R3195 9531 9532 1
R3196 9631 9632 1
R3197 9731 9732 1
R3198 9831 9832 1
R3199 9931 9932 1
R3200 32 33 1
R3201 132 133 1
R3202 232 233 1
R3203 332 333 1
R3204 432 433 1
R3205 532 533 1
R3206 632 633 1
R3207 732 733 1
R3208 832 833 1
R3209 932 933 1
R3210 1032 1033 1
R3211 1132 1133 1
R3212 1232 1233 1
R3213 1332 1333 1
R3214 1432 1433 1
R3215 1532 1533 1
R3216 1632 1633 1
R3217 1732 1733 1
R3218 1832 1833 1
R3219 1932 1933 1
R3220 2032 2033 1
R3221 2132 2133 1
R3222 2232 2233 1
R3223 2332 2333 1
R3224 2432 2433 1
R3225 2532 2533 1
R3226 2632 2633 1
R3227 2732 2733 1
R3228 2832 2833 1
R3229 2932 2933 1
R3230 3032 3033 1
R3231 3132 3133 1
R3232 3232 3233 1
R3233 3332 3333 1
R3234 3432 3433 1
R3235 3532 3533 1
R3236 3632 3633 1
R3237 3732 3733 1
R3238 3832 3833 1
R3239 3932 3933 1
R3240 4032 4033 1
R3241 4132 4133 1
R3242 4232 4233 1
R3243 4332 4333 1
R3244 4432 4433 1
R3245 4532 4533 1
R3246 4632 4633 1
R3247 4732 4733 1
R3248 4832 4833 1
R3249 4932 4933 1
R3250 5032 5033 1
R3251 5132 5133 1
R3252 5232 5233 1
R3253 5332 5333 1
R3254 5432 5433 1
R3255 5532 5533 1
R3256 5632 5633 1
R3257 5732 5733 1
R3258 5832 5833 1
R3259 5932 5933 1
R3260 6032 6033 1
R3261 6132 6133 1
R3262 6232 6233 1
R3263 6332 6333 1
R3264 6432 6433 1
R3265 6532 6533 1
R3266 6632 6633 1
R3267 6732 6733 1
R3268 6832 6833 1
R3269 6932 6933 1
R3270 7032 7033 1
R3271 7132 7133 1
R3272 7232 7233 1
R3273 7332 7333 1
R3274 7432 7433 1
R3275 7532 7533 1
R3276 7632 7633 1
R3277 7732 7733 1
R3278 7832 7833 1
R3279 7932 7933 1
R3280 8032 8033 1
R3281 8132 8133 1
R3282 8232 8233 1
R3283 8332 8333 1
R3284 8432 8433 1
R3285 8532 8533 1
R3286 8632 8633 1
R3287 8732 8733 1
R3288 8832 8833 1
R3289 8932 8933 1
R3290 9032 9033 1
R3291 9132 9133 1
R3292 9232 9233 1
R3293 9332 9333 1
R3294 9432 9433 1
R3295 9532 9533 1
R3296 9632 9633 1
R3297 9732 9733 1
R3298 9832 9833 1
R3299 9932 9933 1
R3300 33 34 1
R3301 133 134 1
R3302 233 234 1
R3303 333 334 1
R3304 433 434 1
R3305 533 534 1
R3306 633 634 1
R3307 733 734 1
R3308 833 834 1
R3309 933 934 1
R3310 1033 1034 1
R3311 1133 1134 1
R3312 1233 1234 1
R3313 1333 1334 1
R3314 1433 1434 1
R3315 1533 1534 1
R3316 1633 1634 1
R3317 1733 1734 1
R3318 1833 1834 1
R3319 1933 1934 1
R3320 2033 2034 1
R3321 2133 2134 1
R3322 2233 2234 1
R3323 2333 2334 1
R3324 2433 2434 1
R3325 2533 2534 1
R3326 2633 2634 1
R3327 2733 2734 1
R3328 2833 2834 1
R3329 2933 2934 1
R3330 3033 3034 1
R3331 3133 3134 1
R3332 3233 3234 1
R3333 3333 3334 1
R3334 3433 3434 1
R3335 3533 3534 1
R3336 3633 3634 1
R3337 3733 3734 1
R3338 3833 3834 1
R3339 3933 3934 1
R3340 4033 4034 1
R3341 4133 4134 1
R3342 4233 4234 1
R3343 4333 4334 1
R3344 4433 4434 1
R3345 4533 4534 1
R3346 4633 4634 1
R3347 4733 4734 1
R3348 4833 4834 1
R3349 4933 4934 1
R3350 5033 5034 1
R3351 5133 5134 1
R3352 5233 5234 1
R3353 5333 5334 1
R3354 5433 5434 1
R3355 5533 5534 1
R3356 5633 5634 1
R3357 5733 5734 1
R3358 5833 5834 1
R3359 5933 5934 1
R3360 6033 6034 1
R3361 6133 6134 1
R3362 6233 6234 1
R3363 6333 6334 1
R3364 6433 6434 1
R3365 6533 6534 1
R3366 6633 6634 1
R3367 6733 6734 1
R3368 6833 6834 1
R3369 6933 6934 1
R3370 7033 7034 1
R3371 7133 7134 1
R3372 7233 7234 1
R3373 7333 7334 1
R3374 7433 7434 1
R3375 7533 7534 1
R3376 7633 7634 1
R3377 7733 7734 1
R3378 7833 7834 1
R3379 7933 7934 1
R3380 8033 8034 1
R3381 8133 8134 1
R3382 8233 8234 1
R3383 8333 8334 1
R3384 8433 8434 1
R3385 8533 8534 1
R3386 8633 8634 1
R3387 8733 8734 1
R3388 8833 8834 1
R3389 8933 8934 1
R3390 9033 9034 1
R3391 9133 9134 1
R3392 9233 9234 1
R3393 9333 9334 1
R3394 9433 9434 1
R3395 9533 9534 1
R3396 9633 9634 1
R3397 9733 9734 1
R3398 9833 9834 1
R3399 9933 9934 1
R3400 34 35 1
R3401 134 135 1
R3402 234 235 1
R3403 334 335 1
R3404 434 435 1
R3405 534 535 1
R3406 634 635 1
R3407 734 735 1
R3408 834 835 1
R3409 934 935 1
R3410 1034 1035 1
R3411 1134 1135 1
R3412 1234 1235 1
R3413 1334 1335 1
R3414 1434 1435 1
R3415 1534 1535 1
R3416 1634 1635 1
R3417 1734 1735 1
R3418 1834 1835 1
R3419 1934 1935 1
R3420 2034 2035 1
R3421 2134 2135 1
R3422 2234 2235 1
R3423 2334 2335 1
R3424 2434 2435 1
R3425 2534 2535 1
R3426 2634 2635 1
R3427 2734 2735 1
R3428 2834 2835 1
R3429 2934 2935 1
R3430 3034 3035 1
R3431 3134 3135 1
R3432 3234 3235 1
R3433 3334 3335 1
R3434 3434 3435 1
R3435 3534 3535 1
R3436 3634 3635 1
R3437 3734 3735 1
R3438 3834 3835 1
R3439 3934 3935 1
R3440 4034 4035 1
R3441 4134 4135 1
R3442 4234 4235 1
R3443 4334 4335 1
R3444 4434 4435 1
R3445 4534 4535 1
R3446 4634 4635 1
R3447 4734 4735 1
R3448 4834 4835 1
R3449 4934 4935 1
R3450 5034 5035 1
R3451 5134 5135 1
R3452 5234 5235 1
R3453 5334 5335 1
R3454 5434 5435 1
R3455 5534 5535 1
R3456 5634 5635 1
R3457 5734 5735 1
R3458 5834 5835 1
R3459 5934 5935 1
R3460 6034 6035 1
R3461 6134 6135 1
R3462 6234 6235 1
R3463 6334 6335 1
R3464 6434 6435 1
R3465 6534 6535 1
R3466 6634 6635 1
R3467 6734 6735 1
R3468 6834 6835 1
R3469 6934 6935 1
R3470 7034 7035 1
R3471 7134 7135 1
R3472 7234 7235 1
R3473 7334 7335 1
R3474 7434 7435 1
R3475 7534 7535 1
R3476 7634 7635 1
R3477 7734 7735 1
R3478 7834 7835 1
R3479 7934 7935 1
R3480 8034 8035 1
R3481 8134 8135 1
R3482 8234 8235 1
R3483 8334 8335 1
R3484 8434 8435 1
R3485 8534 8535 1
R3486 8634 8635 1
R3487 8734 8735 1
R3488 8834 8835 1
R3489 8934 8935 1
R3490 9034 9035 1
R3491 9134 9135 1
R3492 9234 9235 1
R3493 9334 9335 1
R3494 9434 9435 1
R3495 9534 9535 1
R3496 9634 9635 1
R3497 9734 9735 1
R3498 9834 9835 1
R3499 9934 9935 1
R3500 35 36 1
R3501 135 136 1
R3502 235 236 1
R3503 335 336 1
R3504 435 436 1
R3505 535 536 1
R3506 635 636 1
R3507 735 736 1
R3508 835 836 1
R3509 935 936 1
R3510 1035 1036 1
R3511 1135 1136 1
R3512 1235 1236 1
R3513 1335 1336 1
R3514 1435 1436 1
R3515 1535 1536 1
R3516 1635 1636 1
R3517 1735 1736 1
R3518 1835 1836 1
R3519 1935 1936 1
R3520 2035 2036 1
R3521 2135 2136 1
R3522 2235 2236 1
R3523 2335 2336 1
R3524 2435 2436 1
R3525 2535 2536 1
R3526 2635 2636 1
R3527 2735 2736 1
R3528 2835 2836 1
R3529 2935 2936 1
R3530 3035 3036 1
R3531 3135 3136 1
R3532 3235 3236 1
R3533 3335 3336 1
R3534 3435 3436 1
R3535 3535 3536 1
R3536 3635 3636 1
R3537 3735 3736 1
R3538 3835 3836 1
R3539 3935 3936 1
R3540 4035 4036 1
R3541 4135 4136 1
R3542 4235 4236 1
R3543 4335 4336 1
R3544 4435 4436 1
R3545 4535 4536 1
R3546 4635 4636 1
R3547 4735 4736 1
R3548 4835 4836 1
R3549 4935 4936 1
R3550 5035 5036 1
R3551 5135 5136 1
R3552 5235 5236 1
R3553 5335 5336 1
R3554 5435 5436 1
R3555 5535 5536 1
R3556 5635 5636 1
R3557 5735 5736 1
R3558 5835 5836 1
R3559 5935 5936 1
R3560 6035 6036 1
R3561 6135 6136 1
R3562 6235 6236 1
R3563 6335 6336 1
R3564 6435 6436 1
R3565 6535 6536 1
R3566 6635 6636 1
R3567 6735 6736 1
R3568 6835 6836 1
R3569 6935 6936 1
R3570 7035 7036 1
R3571 7135 7136 1
R3572 7235 7236 1
R3573 7335 7336 1
R3574 7435 7436 1
R3575 7535 7536 1
R3576 7635 7636 1
R3577 7735 7736 1
R3578 7835 7836 1
R3579 7935 7936 1
R3580 8035 8036 1
R3581 8135 8136 1
R3582 8235 8236 1
R3583 8335 8336 1
R3584 8435 8436 1
R3585 8535 8536 1
R3586 8635 8636 1
R3587 8735 8736 1
R3588 8835 8836 1
R3589 8935 8936 1
R3590 9035 9036 1
R3591 9135 9136 1
R3592 9235 9236 1
R3593 9335 9336 1
R3594 9435 9436 1
R3595 9535 9536 1
R3596 9635 9636 1
R3597 9735 9736 1
R3598 9835 9836 1
R3599 9935 9936 1
R3600 36 37 1
R3601 136 137 1
R3602 236 237 1
R3603 336 337 1
R3604 436 437 1
R3605 536 537 1
R3606 636 637 1
R3607 736 737 1
R3608 836 837 1
R3609 936 937 1
R3610 1036 1037 1
R3611 1136 1137 1
R3612 1236 1237 1
R3613 1336 1337 1
R3614 1436 1437 1
R3615 1536 1537 1
R3616 1636 1637 1
R3617 1736 1737 1
R3618 1836 1837 1
R3619 1936 1937 1
R3620 2036 2037 1
R3621 2136 2137 1
R3622 2236 2237 1
R3623 2336 2337 1
R3624 2436 2437 1
R3625 2536 2537 1
R3626 2636 2637 1
R3627 2736 2737 1
R3628 2836 2837 1
R3629 2936 2937 1
R3630 3036 3037 1
R3631 3136 3137 1
R3632 3236 3237 1
R3633 3336 3337 1
R3634 3436 3437 1
R3635 3536 3537 1
R3636 3636 3637 1
R3637 3736 3737 1
R3638 3836 3837 1
R3639 3936 3937 1
R3640 4036 4037 1
R3641 4136 4137 1
R3642 4236 4237 1
R3643 4336 4337 1
R3644 4436 4437 1
R3645 4536 4537 1
R3646 4636 4637 1
R3647 4736 4737 1
R3648 4836 4837 1
R3649 4936 4937 1
R3650 5036 5037 1
R3651 5136 5137 1
R3652 5236 5237 1
R3653 5336 5337 1
R3654 5436 5437 1
R3655 5536 5537 1
R3656 5636 5637 1
R3657 5736 5737 1
R3658 5836 5837 1
R3659 5936 5937 1
R3660 6036 6037 1
R3661 6136 6137 1
R3662 6236 6237 1
R3663 6336 6337 1
R3664 6436 6437 1
R3665 6536 6537 1
R3666 6636 6637 1
R3667 6736 6737 1
R3668 6836 6837 1
R3669 6936 6937 1
R3670 7036 7037 1
R3671 7136 7137 1
R3672 7236 7237 1
R3673 7336 7337 1
R3674 7436 7437 1
R3675 7536 7537 1
R3676 7636 7637 1
R3677 7736 7737 1
R3678 7836 7837 1
R3679 7936 7937 1
R3680 8036 8037 1
R3681 8136 8137 1
R3682 8236 8237 1
R3683 8336 8337 1
R3684 8436 8437 1
R3685 8536 8537 1
R3686 8636 8637 1
R3687 8736 8737 1
R3688 8836 8837 1
R3689 8936 8937 1
R3690 9036 9037 1
R3691 9136 9137 1
R3692 9236 9237 1
R3693 9336 9337 1
R3694 9436 9437 1
R3695 9536 9537 1
R3696 9636 9637 1
R3697 9736 9737 1
R3698 9836 9837 1
R3699 9936 9937 1
R3700 37 38 1
R3701 137 138 1
R3702 237 238 1
R3703 337 338 1
R3704 437 438 1
R3705 537 538 1
R3706 637 638 1
R3707 737 738 1
R3708 837 838 1
R3709 937 938 1
R3710 1037 1038 1
R3711 1137 1138 1
R3712 1237 1238 1
R3713 1337 1338 1
R3714 1437 1438 1
R3715 1537 1538 1
R3716 1637 1638 1
R3717 1737 1738 1
R3718 1837 1838 1
R3719 1937 1938 1
R3720 2037 2038 1
R3721 2137 2138 1
R3722 2237 2238 1
R3723 2337 2338 1
R3724 2437 2438 1
R3725 2537 2538 1
R3726 2637 2638 1
R3727 2737 2738 1
R3728 2837 2838 1
R3729 2937 2938 1
R3730 3037 3038 1
R3731 3137 3138 1
R3732 3237 3238 1
R3733 3337 3338 1
R3734 3437 3438 1
R3735 3537 3538 1
R3736 3637 3638 1
R3737 3737 3738 1
R3738 3837 3838 1
R3739 3937 3938 1
R3740 4037 4038 1
R3741 4137 4138 1
R3742 4237 4238 1
R3743 4337 4338 1
R3744 4437 4438 1
R3745 4537 4538 1
R3746 4637 4638 1
R3747 4737 4738 1
R3748 4837 4838 1
R3749 4937 4938 1
R3750 5037 5038 1
R3751 5137 5138 1
R3752 5237 5238 1
R3753 5337 5338 1
R3754 5437 5438 1
R3755 5537 5538 1
R3756 5637 5638 1
R3757 5737 5738 1
R3758 5837 5838 1
R3759 5937 5938 1
R3760 6037 6038 1
R3761 6137 6138 1
R3762 6237 6238 1
R3763 6337 6338 1
R3764 6437 6438 1
R3765 6537 6538 1
R3766 6637 6638 1
R3767 6737 6738 1
R3768 6837 6838 1
R3769 6937 6938 1
R3770 7037 7038 1
R3771 7137 7138 1
R3772 7237 7238 1
R3773 7337 7338 1
R3774 7437 7438 1
R3775 7537 7538 1
R3776 7637 7638 1
R3777 7737 7738 1
R3778 7837 7838 1
R3779 7937 7938 1
R3780 8037 8038 1
R3781 8137 8138 1
R3782 8237 8238 1
R3783 8337 8338 1
R3784 8437 8438 1
R3785 8537 8538 1
R3786 8637 8638 1
R3787 8737 8738 1
R3788 8837 8838 1
R3789 8937 8938 1
R3790 9037 9038 1
R3791 9137 9138 1
R3792 9237 9238 1
R3793 9337 9338 1
R3794 9437 9438 1
R3795 9537 9538 1
R3796 9637 9638 1
R3797 9737 9738 1
R3798 9837 9838 1
R3799 9937 9938 1
R3800 38 39 1
R3801 138 139 1
R3802 238 239 1
R3803 338 339 1
R3804 438 439 1
R3805 538 539 1
R3806 638 639 1
R3807 738 739 1
R3808 838 839 1
R3809 938 939 1
R3810 1038 1039 1
R3811 1138 1139 1
R3812 1238 1239 1
R3813 1338 1339 1
R3814 1438 1439 1
R3815 1538 1539 1
R3816 1638 1639 1
R3817 1738 1739 1
R3818 1838 1839 1
R3819 1938 1939 1
R3820 2038 2039 1
R3821 2138 2139 1
R3822 2238 2239 1
R3823 2338 2339 1
R3824 2438 2439 1
R3825 2538 2539 1
R3826 2638 2639 1
R3827 2738 2739 1
R3828 2838 2839 1
R3829 2938 2939 1
R3830 3038 3039 1
R3831 3138 3139 1
R3832 3238 3239 1
R3833 3338 3339 1
R3834 3438 3439 1
R3835 3538 3539 1
R3836 3638 3639 1
R3837 3738 3739 1
R3838 3838 3839 1
R3839 3938 3939 1
R3840 4038 4039 1
R3841 4138 4139 1
R3842 4238 4239 1
R3843 4338 4339 1
R3844 4438 4439 1
R3845 4538 4539 1
R3846 4638 4639 1
R3847 4738 4739 1
R3848 4838 4839 1
R3849 4938 4939 1
R3850 5038 5039 1
R3851 5138 5139 1
R3852 5238 5239 1
R3853 5338 5339 1
R3854 5438 5439 1
R3855 5538 5539 1
R3856 5638 5639 1
R3857 5738 5739 1
R3858 5838 5839 1
R3859 5938 5939 1
R3860 6038 6039 1
R3861 6138 6139 1
R3862 6238 6239 1
R3863 6338 6339 1
R3864 6438 6439 1
R3865 6538 6539 1
R3866 6638 6639 1
R3867 6738 6739 1
R3868 6838 6839 1
R3869 6938 6939 1
R3870 7038 7039 1
R3871 7138 7139 1
R3872 7238 7239 1
R3873 7338 7339 1
R3874 7438 7439 1
R3875 7538 7539 1
R3876 7638 7639 1
R3877 7738 7739 1
R3878 7838 7839 1
R3879 7938 7939 1
R3880 8038 8039 1
R3881 8138 8139 1
R3882 8238 8239 1
R3883 8338 8339 1
R3884 8438 8439 1
R3885 8538 8539 1
R3886 8638 8639 1
R3887 8738 8739 1
R3888 8838 8839 1
R3889 8938 8939 1
R3890 9038 9039 1
R3891 9138 9139 1
R3892 9238 9239 1
R3893 9338 9339 1
R3894 9438 9439 1
R3895 9538 9539 1
R3896 9638 9639 1
R3897 9738 9739 1
R3898 9838 9839 1
R3899 9938 9939 1
R3900 39 40 1
R3901 139 140 1
R3902 239 240 1
R3903 339 340 1
R3904 439 440 1
R3905 539 540 1
R3906 639 640 1
R3907 739 740 1
R3908 839 840 1
R3909 939 940 1
R3910 1039 1040 1
R3911 1139 1140 1
R3912 1239 1240 1
R3913 1339 1340 1
R3914 1439 1440 1
R3915 1539 1540 1
R3916 1639 1640 1
R3917 1739 1740 1
R3918 1839 1840 1
R3919 1939 1940 1
R3920 2039 2040 1
R3921 2139 2140 1
R3922 2239 2240 1
R3923 2339 2340 1
R3924 2439 2440 1
R3925 2539 2540 1
R3926 2639 2640 1
R3927 2739 2740 1
R3928 2839 2840 1
R3929 2939 2940 1
R3930 3039 3040 1
R3931 3139 3140 1
R3932 3239 3240 1
R3933 3339 3340 1
R3934 3439 3440 1
R3935 3539 3540 1
R3936 3639 3640 1
R3937 3739 3740 1
R3938 3839 3840 1
R3939 3939 3940 1
R3940 4039 4040 1
R3941 4139 4140 1
R3942 4239 4240 1
R3943 4339 4340 1
R3944 4439 4440 1
R3945 4539 4540 1
R3946 4639 4640 1
R3947 4739 4740 1
R3948 4839 4840 1
R3949 4939 4940 1
R3950 5039 5040 1
R3951 5139 5140 1
R3952 5239 5240 1
R3953 5339 5340 1
R3954 5439 5440 1
R3955 5539 5540 1
R3956 5639 5640 1
R3957 5739 5740 1
R3958 5839 5840 1
R3959 5939 5940 1
R3960 6039 6040 1
R3961 6139 6140 1
R3962 6239 6240 1
R3963 6339 6340 1
R3964 6439 6440 1
R3965 6539 6540 1
R3966 6639 6640 1
R3967 6739 6740 1
R3968 6839 6840 1
R3969 6939 6940 1
R3970 7039 7040 1
R3971 7139 7140 1
R3972 7239 7240 1
R3973 7339 7340 1
R3974 7439 7440 1
R3975 7539 7540 1
R3976 7639 7640 1
R3977 7739 7740 1
R3978 7839 7840 1
R3979 7939 7940 1
R3980 8039 8040 1
R3981 8139 8140 1
R3982 8239 8240 1
R3983 8339 8340 1
R3984 8439 8440 1
R3985 8539 8540 1
R3986 8639 8640 1
R3987 8739 8740 1
R3988 8839 8840 1
R3989 8939 8940 1
R3990 9039 9040 1
R3991 9139 9140 1
R3992 9239 9240 1
R3993 9339 9340 1
R3994 9439 9440 1
R3995 9539 9540 1
R3996 9639 9640 1
R3997 9739 9740 1
R3998 9839 9840 1
R3999 9939 9940 1
R4000 40 41 1
R4001 140 141 1
R4002 240 241 1
R4003 340 341 1
R4004 440 441 1
R4005 540 541 1
R4006 640 641 1
R4007 740 741 1
R4008 840 841 1
R4009 940 941 1
R4010 1040 1041 1
R4011 1140 1141 1
R4012 1240 1241 1
R4013 1340 1341 1
R4014 1440 1441 1
R4015 1540 1541 1
R4016 1640 1641 1
R4017 1740 1741 1
R4018 1840 1841 1
R4019 1940 1941 1
R4020 2040 2041 1
R4021 2140 2141 1
R4022 2240 2241 1
R4023 2340 2341 1
R4024 2440 2441 1
R4025 2540 2541 1
R4026 2640 2641 1
R4027 2740 2741 1
R4028 2840 2841 1
R4029 2940 2941 1
R4030 3040 3041 1
R4031 3140 3141 1
R4032 3240 3241 1
R4033 3340 3341 1
R4034 3440 3441 1
R4035 3540 3541 1
R4036 3640 3641 1
R4037 3740 3741 1
R4038 3840 3841 1
R4039 3940 3941 1
R4040 4040 4041 1
R4041 4140 4141 1
R4042 4240 4241 1
R4043 4340 4341 1
R4044 4440 4441 1
R4045 4540 4541 1
R4046 4640 4641 1
R4047 4740 4741 1
R4048 4840 4841 1
R4049 4940 4941 1
R4050 5040 5041 1
R4051 5140 5141 1
R4052 5240 5241 1
R4053 5340 5341 1
R4054 5440 5441 1
R4055 5540 5541 1
R4056 5640 5641 1
R4057 5740 5741 1
R4058 5840 5841 1
R4059 5940 5941 1
R4060 6040 6041 1
R4061 6140 6141 1
R4062 6240 6241 1
R4063 6340 6341 1
R4064 6440 6441 1
R4065 6540 6541 1
R4066 6640 6641 1
R4067 6740 6741 1
R4068 6840 6841 1
R4069 6940 6941 1
R4070 7040 7041 1
R4071 7140 7141 1
R4072 7240 7241 1
R4073 7340 7341 1
R4074 7440 7441 1
R4075 7540 7541 1
R4076 7640 7641 1
R4077 7740 7741 1
R4078 7840 7841 1
R4079 7940 7941 1
R4080 8040 8041 1
R4081 8140 8141 1
R4082 8240 8241 1
R4083 8340 8341 1
R4084 8440 8441 1
R4085 8540 8541 1
R4086 8640 8641 1
R4087 8740 8741 1
R4088 8840 8841 1
R4089 8940 8941 1
R4090 9040 9041 1
R4091 9140 9141 1
R4092 9240 9241 1
R4093 9340 9341 1
R4094 9440 9441 1
R4095 9540 9541 1
R4096 9640 9641 1
R4097 9740 9741 1
R4098 9840 9841 1
R4099 9940 9941 1
R4100 41 42 1
R4101 141 142 1
R4102 241 242 1
R4103 341 342 1
R4104 441 442 1
R4105 541 542 1
R4106 641 642 1
R4107 741 742 1
R4108 841 842 1
R4109 941 942 1
R4110 1041 1042 1
R4111 1141 1142 1
R4112 1241 1242 1
R4113 1341 1342 1
R4114 1441 1442 1
R4115 1541 1542 1
R4116 1641 1642 1
R4117 1741 1742 1
R4118 1841 1842 1
R4119 1941 1942 1
R4120 2041 2042 1
R4121 2141 2142 1
R4122 2241 2242 1
R4123 2341 2342 1
R4124 2441 2442 1
R4125 2541 2542 1
R4126 2641 2642 1
R4127 2741 2742 1
R4128 2841 2842 1
R4129 2941 2942 1
R4130 3041 3042 1
R4131 3141 3142 1
R4132 3241 3242 1
R4133 3341 3342 1
R4134 3441 3442 1
R4135 3541 3542 1
R4136 3641 3642 1
R4137 3741 3742 1
R4138 3841 3842 1
R4139 3941 3942 1
R4140 4041 4042 1
R4141 4141 4142 1
R4142 4241 4242 1
R4143 4341 4342 1
R4144 4441 4442 1
R4145 4541 4542 1
R4146 4641 4642 1
R4147 4741 4742 1
R4148 4841 4842 1
R4149 4941 4942 1
R4150 5041 5042 1
R4151 5141 5142 1
R4152 5241 5242 1
R4153 5341 5342 1
R4154 5441 5442 1
R4155 5541 5542 1
R4156 5641 5642 1
R4157 5741 5742 1
R4158 5841 5842 1
R4159 5941 5942 1
R4160 6041 6042 1
R4161 6141 6142 1
R4162 6241 6242 1
R4163 6341 6342 1
R4164 6441 6442 1
R4165 6541 6542 1
R4166 6641 6642 1
R4167 6741 6742 1
R4168 6841 6842 1
R4169 6941 6942 1
R4170 7041 7042 1
R4171 7141 7142 1
R4172 7241 7242 1
R4173 7341 7342 1
R4174 7441 7442 1
R4175 7541 7542 1
R4176 7641 7642 1
R4177 7741 7742 1
R4178 7841 7842 1
R4179 7941 7942 1
R4180 8041 8042 1
R4181 8141 8142 1
R4182 8241 8242 1
R4183 8341 8342 1
R4184 8441 8442 1
R4185 8541 8542 1
R4186 8641 8642 1
R4187 8741 8742 1
R4188 8841 8842 1
R4189 8941 8942 1
R4190 9041 9042 1
R4191 9141 9142 1
R4192 9241 9242 1
R4193 9341 9342 1
R4194 9441 9442 1
R4195 9541 9542 1
R4196 9641 9642 1
R4197 9741 9742 1
R4198 9841 9842 1
R4199 9941 9942 1
R4200 42 43 1
R4201 142 143 1
R4202 242 243 1
R4203 342 343 1
R4204 442 443 1
R4205 542 543 1
R4206 642 643 1
R4207 742 743 1
R4208 842 843 1
R4209 942 943 1
R4210 1042 1043 1
R4211 1142 1143 1
R4212 1242 1243 1
R4213 1342 1343 1
R4214 1442 1443 1
R4215 1542 1543 1
R4216 1642 1643 1
R4217 1742 1743 1
R4218 1842 1843 1
R4219 1942 1943 1
R4220 2042 2043 1
R4221 2142 2143 1
R4222 2242 2243 1
R4223 2342 2343 1
R4224 2442 2443 1
R4225 2542 2543 1
R4226 2642 2643 1
R4227 2742 2743 1
R4228 2842 2843 1
R4229 2942 2943 1
R4230 3042 3043 1
R4231 3142 3143 1
R4232 3242 3243 1
R4233 3342 3343 1
R4234 3442 3443 1
R4235 3542 3543 1
R4236 3642 3643 1
R4237 3742 3743 1
R4238 3842 3843 1
R4239 3942 3943 1
R4240 4042 4043 1
R4241 4142 4143 1
R4242 4242 4243 1
R4243 4342 4343 1
R4244 4442 4443 1
R4245 4542 4543 1
R4246 4642 4643 1
R4247 4742 4743 1
R4248 4842 4843 1
R4249 4942 4943 1
R4250 5042 5043 1
R4251 5142 5143 1
R4252 5242 5243 1
R4253 5342 5343 1
R4254 5442 5443 1
R4255 5542 5543 1
R4256 5642 5643 1
R4257 5742 5743 1
R4258 5842 5843 1
R4259 5942 5943 1
R4260 6042 6043 1
R4261 6142 6143 1
R4262 6242 6243 1
R4263 6342 6343 1
R4264 6442 6443 1
R4265 6542 6543 1
R4266 6642 6643 1
R4267 6742 6743 1
R4268 6842 6843 1
R4269 6942 6943 1
R4270 7042 7043 1
R4271 7142 7143 1
R4272 7242 7243 1
R4273 7342 7343 1
R4274 7442 7443 1
R4275 7542 7543 1
R4276 7642 7643 1
R4277 7742 7743 1
R4278 7842 7843 1
R4279 7942 7943 1
R4280 8042 8043 1
R4281 8142 8143 1
R4282 8242 8243 1
R4283 8342 8343 1
R4284 8442 8443 1
R4285 8542 8543 1
R4286 8642 8643 1
R4287 8742 8743 1
R4288 8842 8843 1
R4289 8942 8943 1
R4290 9042 9043 1
R4291 9142 9143 1
R4292 9242 9243 1
R4293 9342 9343 1
R4294 9442 9443 1
R4295 9542 9543 1
R4296 9642 9643 1
R4297 9742 9743 1
R4298 9842 9843 1
R4299 9942 9943 1
R4300 43 44 1
R4301 143 144 1
R4302 243 244 1
R4303 343 344 1
R4304 443 444 1
R4305 543 544 1
R4306 643 644 1
R4307 743 744 1
R4308 843 844 1
R4309 943 944 1
R4310 1043 1044 1
R4311 1143 1144 1
R4312 1243 1244 1
R4313 1343 1344 1
R4314 1443 1444 1
R4315 1543 1544 1
R4316 1643 1644 1
R4317 1743 1744 1
R4318 1843 1844 1
R4319 1943 1944 1
R4320 2043 2044 1
R4321 2143 2144 1
R4322 2243 2244 1
R4323 2343 2344 1
R4324 2443 2444 1
R4325 2543 2544 1
R4326 2643 2644 1
R4327 2743 2744 1
R4328 2843 2844 1
R4329 2943 2944 1
R4330 3043 3044 1
R4331 3143 3144 1
R4332 3243 3244 1
R4333 3343 3344 1
R4334 3443 3444 1
R4335 3543 3544 1
R4336 3643 3644 1
R4337 3743 3744 1
R4338 3843 3844 1
R4339 3943 3944 1
R4340 4043 4044 1
R4341 4143 4144 1
R4342 4243 4244 1
R4343 4343 4344 1
R4344 4443 4444 1
R4345 4543 4544 1
R4346 4643 4644 1
R4347 4743 4744 1
R4348 4843 4844 1
R4349 4943 4944 1
R4350 5043 5044 1
R4351 5143 5144 1
R4352 5243 5244 1
R4353 5343 5344 1
R4354 5443 5444 1
R4355 5543 5544 1
R4356 5643 5644 1
R4357 5743 5744 1
R4358 5843 5844 1
R4359 5943 5944 1
R4360 6043 6044 1
R4361 6143 6144 1
R4362 6243 6244 1
R4363 6343 6344 1
R4364 6443 6444 1
R4365 6543 6544 1
R4366 6643 6644 1
R4367 6743 6744 1
R4368 6843 6844 1
R4369 6943 6944 1
R4370 7043 7044 1
R4371 7143 7144 1
R4372 7243 7244 1
R4373 7343 7344 1
R4374 7443 7444 1
R4375 7543 7544 1
R4376 7643 7644 1
R4377 7743 7744 1
R4378 7843 7844 1
R4379 7943 7944 1
R4380 8043 8044 1
R4381 8143 8144 1
R4382 8243 8244 1
R4383 8343 8344 1
R4384 8443 8444 1
R4385 8543 8544 1
R4386 8643 8644 1
R4387 8743 8744 1
R4388 8843 8844 1
R4389 8943 8944 1
R4390 9043 9044 1
R4391 9143 9144 1
R4392 9243 9244 1
R4393 9343 9344 1
R4394 9443 9444 1
R4395 9543 9544 1
R4396 9643 9644 1
R4397 9743 9744 1
R4398 9843 9844 1
R4399 9943 9944 1
R4400 44 45 1
R4401 144 145 1
R4402 244 245 1
R4403 344 345 1
R4404 444 445 1
R4405 544 545 1
R4406 644 645 1
R4407 744 745 1
R4408 844 845 1
R4409 944 945 1
R4410 1044 1045 1
R4411 1144 1145 1
R4412 1244 1245 1
R4413 1344 1345 1
R4414 1444 1445 1
R4415 1544 1545 1
R4416 1644 1645 1
R4417 1744 1745 1
R4418 1844 1845 1
R4419 1944 1945 1
R4420 2044 2045 1
R4421 2144 2145 1
R4422 2244 2245 1
R4423 2344 2345 1
R4424 2444 2445 1
R4425 2544 2545 1
R4426 2644 2645 1
R4427 2744 2745 1
R4428 2844 2845 1
R4429 2944 2945 1
R4430 3044 3045 1
R4431 3144 3145 1
R4432 3244 3245 1
R4433 3344 3345 1
R4434 3444 3445 1
R4435 3544 3545 1
R4436 3644 3645 1
R4437 3744 3745 1
R4438 3844 3845 1
R4439 3944 3945 1
R4440 4044 4045 1
R4441 4144 4145 1
R4442 4244 4245 1
R4443 4344 4345 1
R4444 4444 4445 1
R4445 4544 4545 1
R4446 4644 4645 1
R4447 4744 4745 1
R4448 4844 4845 1
R4449 4944 4945 1
R4450 5044 5045 1
R4451 5144 5145 1
R4452 5244 5245 1
R4453 5344 5345 1
R4454 5444 5445 1
R4455 5544 5545 1
R4456 5644 5645 1
R4457 5744 5745 1
R4458 5844 5845 1
R4459 5944 5945 1
R4460 6044 6045 1
R4461 6144 6145 1
R4462 6244 6245 1
R4463 6344 6345 1
R4464 6444 6445 1
R4465 6544 6545 1
R4466 6644 6645 1
R4467 6744 6745 1
R4468 6844 6845 1
R4469 6944 6945 1
R4470 7044 7045 1
R4471 7144 7145 1
R4472 7244 7245 1
R4473 7344 7345 1
R4474 7444 7445 1
R4475 7544 7545 1
R4476 7644 7645 1
R4477 7744 7745 1
R4478 7844 7845 1
R4479 7944 7945 1
R4480 8044 8045 1
R4481 8144 8145 1
R4482 8244 8245 1
R4483 8344 8345 1
R4484 8444 8445 1
R4485 8544 8545 1
R4486 8644 8645 1
R4487 8744 8745 1
R4488 8844 8845 1
R4489 8944 8945 1
R4490 9044 9045 1
R4491 9144 9145 1
R4492 9244 9245 1
R4493 9344 9345 1
R4494 9444 9445 1
R4495 9544 9545 1
R4496 9644 9645 1
R4497 9744 9745 1
R4498 9844 9845 1
R4499 9944 9945 1
R4500 45 46 1
R4501 145 146 1
R4502 245 246 1
R4503 345 346 1
R4504 445 446 1
R4505 545 546 1
R4506 645 646 1
R4507 745 746 1
R4508 845 846 1
R4509 945 946 1
R4510 1045 1046 1
R4511 1145 1146 1
R4512 1245 1246 1
R4513 1345 1346 1
R4514 1445 1446 1
R4515 1545 1546 1
R4516 1645 1646 1
R4517 1745 1746 1
R4518 1845 1846 1
R4519 1945 1946 1
R4520 2045 2046 1
R4521 2145 2146 1
R4522 2245 2246 1
R4523 2345 2346 1
R4524 2445 2446 1
R4525 2545 2546 1
R4526 2645 2646 1
R4527 2745 2746 1
R4528 2845 2846 1
R4529 2945 2946 1
R4530 3045 3046 1
R4531 3145 3146 1
R4532 3245 3246 1
R4533 3345 3346 1
R4534 3445 3446 1
R4535 3545 3546 1
R4536 3645 3646 1
R4537 3745 3746 1
R4538 3845 3846 1
R4539 3945 3946 1
R4540 4045 4046 1
R4541 4145 4146 1
R4542 4245 4246 1
R4543 4345 4346 1
R4544 4445 4446 1
R4545 4545 4546 1
R4546 4645 4646 1
R4547 4745 4746 1
R4548 4845 4846 1
R4549 4945 4946 1
R4550 5045 5046 1
R4551 5145 5146 1
R4552 5245 5246 1
R4553 5345 5346 1
R4554 5445 5446 1
R4555 5545 5546 1
R4556 5645 5646 1
R4557 5745 5746 1
R4558 5845 5846 1
R4559 5945 5946 1
R4560 6045 6046 1
R4561 6145 6146 1
R4562 6245 6246 1
R4563 6345 6346 1
R4564 6445 6446 1
R4565 6545 6546 1
R4566 6645 6646 1
R4567 6745 6746 1
R4568 6845 6846 1
R4569 6945 6946 1
R4570 7045 7046 1
R4571 7145 7146 1
R4572 7245 7246 1
R4573 7345 7346 1
R4574 7445 7446 1
R4575 7545 7546 1
R4576 7645 7646 1
R4577 7745 7746 1
R4578 7845 7846 1
R4579 7945 7946 1
R4580 8045 8046 1
R4581 8145 8146 1
R4582 8245 8246 1
R4583 8345 8346 1
R4584 8445 8446 1
R4585 8545 8546 1
R4586 8645 8646 1
R4587 8745 8746 1
R4588 8845 8846 1
R4589 8945 8946 1
R4590 9045 9046 1
R4591 9145 9146 1
R4592 9245 9246 1
R4593 9345 9346 1
R4594 9445 9446 1
R4595 9545 9546 1
R4596 9645 9646 1
R4597 9745 9746 1
R4598 9845 9846 1
R4599 9945 9946 1
R4600 46 47 1
R4601 146 147 1
R4602 246 247 1
R4603 346 347 1
R4604 446 447 1
R4605 546 547 1
R4606 646 647 1
R4607 746 747 1
R4608 846 847 1
R4609 946 947 1
R4610 1046 1047 1
R4611 1146 1147 1
R4612 1246 1247 1
R4613 1346 1347 1
R4614 1446 1447 1
R4615 1546 1547 1
R4616 1646 1647 1
R4617 1746 1747 1
R4618 1846 1847 1
R4619 1946 1947 1
R4620 2046 2047 1
R4621 2146 2147 1
R4622 2246 2247 1
R4623 2346 2347 1
R4624 2446 2447 1
R4625 2546 2547 1
R4626 2646 2647 1
R4627 2746 2747 1
R4628 2846 2847 1
R4629 2946 2947 1
R4630 3046 3047 1
R4631 3146 3147 1
R4632 3246 3247 1
R4633 3346 3347 1
R4634 3446 3447 1
R4635 3546 3547 1
R4636 3646 3647 1
R4637 3746 3747 1
R4638 3846 3847 1
R4639 3946 3947 1
R4640 4046 4047 1
R4641 4146 4147 1
R4642 4246 4247 1
R4643 4346 4347 1
R4644 4446 4447 1
R4645 4546 4547 1
R4646 4646 4647 1
R4647 4746 4747 1
R4648 4846 4847 1
R4649 4946 4947 1
R4650 5046 5047 1
R4651 5146 5147 1
R4652 5246 5247 1
R4653 5346 5347 1
R4654 5446 5447 1
R4655 5546 5547 1
R4656 5646 5647 1
R4657 5746 5747 1
R4658 5846 5847 1
R4659 5946 5947 1
R4660 6046 6047 1
R4661 6146 6147 1
R4662 6246 6247 1
R4663 6346 6347 1
R4664 6446 6447 1
R4665 6546 6547 1
R4666 6646 6647 1
R4667 6746 6747 1
R4668 6846 6847 1
R4669 6946 6947 1
R4670 7046 7047 1
R4671 7146 7147 1
R4672 7246 7247 1
R4673 7346 7347 1
R4674 7446 7447 1
R4675 7546 7547 1
R4676 7646 7647 1
R4677 7746 7747 1
R4678 7846 7847 1
R4679 7946 7947 1
R4680 8046 8047 1
R4681 8146 8147 1
R4682 8246 8247 1
R4683 8346 8347 1
R4684 8446 8447 1
R4685 8546 8547 1
R4686 8646 8647 1
R4687 8746 8747 1
R4688 8846 8847 1
R4689 8946 8947 1
R4690 9046 9047 1
R4691 9146 9147 1
R4692 9246 9247 1
R4693 9346 9347 1
R4694 9446 9447 1
R4695 9546 9547 1
R4696 9646 9647 1
R4697 9746 9747 1
R4698 9846 9847 1
R4699 9946 9947 1
R4700 47 48 1
R4701 147 148 1
R4702 247 248 1
R4703 347 348 1
R4704 447 448 1
R4705 547 548 1
R4706 647 648 1
R4707 747 748 1
R4708 847 848 1
R4709 947 948 1
R4710 1047 1048 1
R4711 1147 1148 1
R4712 1247 1248 1
R4713 1347 1348 1
R4714 1447 1448 1
R4715 1547 1548 1
R4716 1647 1648 1
R4717 1747 1748 1
R4718 1847 1848 1
R4719 1947 1948 1
R4720 2047 2048 1
R4721 2147 2148 1
R4722 2247 2248 1
R4723 2347 2348 1
R4724 2447 2448 1
R4725 2547 2548 1
R4726 2647 2648 1
R4727 2747 2748 1
R4728 2847 2848 1
R4729 2947 2948 1
R4730 3047 3048 1
R4731 3147 3148 1
R4732 3247 3248 1
R4733 3347 3348 1
R4734 3447 3448 1
R4735 3547 3548 1
R4736 3647 3648 1
R4737 3747 3748 1
R4738 3847 3848 1
R4739 3947 3948 1
R4740 4047 4048 1
R4741 4147 4148 1
R4742 4247 4248 1
R4743 4347 4348 1
R4744 4447 4448 1
R4745 4547 4548 1
R4746 4647 4648 1
R4747 4747 4748 1
R4748 4847 4848 1
R4749 4947 4948 1
R4750 5047 5048 1
R4751 5147 5148 1
R4752 5247 5248 1
R4753 5347 5348 1
R4754 5447 5448 1
R4755 5547 5548 1
R4756 5647 5648 1
R4757 5747 5748 1
R4758 5847 5848 1
R4759 5947 5948 1
R4760 6047 6048 1
R4761 6147 6148 1
R4762 6247 6248 1
R4763 6347 6348 1
R4764 6447 6448 1
R4765 6547 6548 1
R4766 6647 6648 1
R4767 6747 6748 1
R4768 6847 6848 1
R4769 6947 6948 1
R4770 7047 7048 1
R4771 7147 7148 1
R4772 7247 7248 1
R4773 7347 7348 1
R4774 7447 7448 1
R4775 7547 7548 1
R4776 7647 7648 1
R4777 7747 7748 1
R4778 7847 7848 1
R4779 7947 7948 1
R4780 8047 8048 1
R4781 8147 8148 1
R4782 8247 8248 1
R4783 8347 8348 1
R4784 8447 8448 1
R4785 8547 8548 1
R4786 8647 8648 1
R4787 8747 8748 1
R4788 8847 8848 1
R4789 8947 8948 1
R4790 9047 9048 1
R4791 9147 9148 1
R4792 9247 9248 1
R4793 9347 9348 1
R4794 9447 9448 1
R4795 9547 9548 1
R4796 9647 9648 1
R4797 9747 9748 1
R4798 9847 9848 1
R4799 9947 9948 1
R4800 48 49 1
R4801 148 149 1
R4802 248 249 1
R4803 348 349 1
R4804 448 449 1
R4805 548 549 1
R4806 648 649 1
R4807 748 749 1
R4808 848 849 1
R4809 948 949 1
R4810 1048 1049 1
R4811 1148 1149 1
R4812 1248 1249 1
R4813 1348 1349 1
R4814 1448 1449 1
R4815 1548 1549 1
R4816 1648 1649 1
R4817 1748 1749 1
R4818 1848 1849 1
R4819 1948 1949 1
R4820 2048 2049 1
R4821 2148 2149 1
R4822 2248 2249 1
R4823 2348 2349 1
R4824 2448 2449 1
R4825 2548 2549 1
R4826 2648 2649 1
R4827 2748 2749 1
R4828 2848 2849 1
R4829 2948 2949 1
R4830 3048 3049 1
R4831 3148 3149 1
R4832 3248 3249 1
R4833 3348 3349 1
R4834 3448 3449 1
R4835 3548 3549 1
R4836 3648 3649 1
R4837 3748 3749 1
R4838 3848 3849 1
R4839 3948 3949 1
R4840 4048 4049 1
R4841 4148 4149 1
R4842 4248 4249 1
R4843 4348 4349 1
R4844 4448 4449 1
R4845 4548 4549 1
R4846 4648 4649 1
R4847 4748 4749 1
R4848 4848 4849 1
R4849 4948 4949 1
R4850 5048 5049 1
R4851 5148 5149 1
R4852 5248 5249 1
R4853 5348 5349 1
R4854 5448 5449 1
R4855 5548 5549 1
R4856 5648 5649 1
R4857 5748 5749 1
R4858 5848 5849 1
R4859 5948 5949 1
R4860 6048 6049 1
R4861 6148 6149 1
R4862 6248 6249 1
R4863 6348 6349 1
R4864 6448 6449 1
R4865 6548 6549 1
R4866 6648 6649 1
R4867 6748 6749 1
R4868 6848 6849 1
R4869 6948 6949 1
R4870 7048 7049 1
R4871 7148 7149 1
R4872 7248 7249 1
R4873 7348 7349 1
R4874 7448 7449 1
R4875 7548 7549 1
R4876 7648 7649 1
R4877 7748 7749 1
R4878 7848 7849 1
R4879 7948 7949 1
R4880 8048 8049 1
R4881 8148 8149 1
R4882 8248 8249 1
R4883 8348 8349 1
R4884 8448 8449 1
R4885 8548 8549 1
R4886 8648 8649 1
R4887 8748 8749 1
R4888 8848 8849 1
R4889 8948 8949 1
R4890 9048 9049 1
R4891 9148 9149 1
R4892 9248 9249 1
R4893 9348 9349 1
R4894 9448 9449 1
R4895 9548 9549 1
R4896 9648 9649 1
R4897 9748 9749 1
R4898 9848 9849 1
R4899 9948 9949 1
R4900 49 50 1
R4901 149 150 1
R4902 249 250 1
R4903 349 350 1
R4904 449 450 1
R4905 549 550 1
R4906 649 650 1
R4907 749 750 1
R4908 849 850 1
R4909 949 950 1
R4910 1049 1050 1
R4911 1149 1150 1
R4912 1249 1250 1
R4913 1349 1350 1
R4914 1449 1450 1
R4915 1549 1550 1
R4916 1649 1650 1
R4917 1749 1750 1
R4918 1849 1850 1
R4919 1949 1950 1
R4920 2049 2050 1
R4921 2149 2150 1
R4922 2249 2250 1
R4923 2349 2350 1
R4924 2449 2450 1
R4925 2549 2550 1
R4926 2649 2650 1
R4927 2749 2750 1
R4928 2849 2850 1
R4929 2949 2950 1
R4930 3049 3050 1
R4931 3149 3150 1
R4932 3249 3250 1
R4933 3349 3350 1
R4934 3449 3450 1
R4935 3549 3550 1
R4936 3649 3650 1
R4937 3749 3750 1
R4938 3849 3850 1
R4939 3949 3950 1
R4940 4049 4050 1
R4941 4149 4150 1
R4942 4249 4250 1
R4943 4349 4350 1
R4944 4449 4450 1
R4945 4549 4550 1
R4946 4649 4650 1
R4947 4749 4750 1
R4948 4849 4850 1
R4949 4949 4950 1
R4950 5049 5050 1
R4951 5149 5150 1
R4952 5249 5250 1
R4953 5349 5350 1
R4954 5449 5450 1
R4955 5549 5550 1
R4956 5649 5650 1
R4957 5749 5750 1
R4958 5849 5850 1
R4959 5949 5950 1
R4960 6049 6050 1
R4961 6149 6150 1
R4962 6249 6250 1
R4963 6349 6350 1
R4964 6449 6450 1
R4965 6549 6550 1
R4966 6649 6650 1
R4967 6749 6750 1
R4968 6849 6850 1
R4969 6949 6950 1
R4970 7049 7050 1
R4971 7149 7150 1
R4972 7249 7250 1
R4973 7349 7350 1
R4974 7449 7450 1
R4975 7549 7550 1
R4976 7649 7650 1
R4977 7749 7750 1
R4978 7849 7850 1
R4979 7949 7950 1
R4980 8049 8050 1
R4981 8149 8150 1
R4982 8249 8250 1
R4983 8349 8350 1
R4984 8449 8450 1
R4985 8549 8550 1
R4986 8649 8650 1
R4987 8749 8750 1
R4988 8849 8850 1
R4989 8949 8950 1
R4990 9049 9050 1
R4991 9149 9150 1
R4992 9249 9250 1
R4993 9349 9350 1
R4994 9449 9450 1
R4995 9549 9550 1
R4996 9649 9650 1
R4997 9749 9750 1
R4998 9849 9850 1
R4999 9949 9950 1
